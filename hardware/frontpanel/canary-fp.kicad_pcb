# Repository stoatworks-labs/canary

File README.md:

# CANary

> **AI-assisted project.** This codebase was created with [Claude](https://claude.com/claude-code)
> (Anthropic), directed and reviewed by a human author.

An open-hardware **IP-to-CAN converter compatible with the d&b audiotechnik R70
Ethernet-to-CAN interface**. It speaks the R70's network protocol, so **R1** can
find it, connect to it and reach CAN-era d&b amplifiers (D6, D12, E-PAC) through
hardware you can build yourself.

**ESP32-S3 · W5500 Ethernet · ADM3053 isolated CAN · USB-C PD power · three
Neutrik etherCONs**, in a one-piece 3D-printed case. A second variant of the
same design, the **CANary Dev Edition**, adds PoE and brings the board's
insides out to a front-panel header ([two variants](#two-variants)).

> **Status: prototype.** **CANary (rev A)** boards have been built. Board #1 passes its
> self-test, takes a DHCP lease, and is discovered and listed by R1 over
> Ethernet. The host-side acceptance run passes 19/19 over Ethernet and over the
> USB network link. On 2026-10-28 it went on a real bus with two d&b amplifiers:
> both answered through the isolation barrier on both CAN jacks, and the control
> application connected through the board and drove mute and gain in both
> directions ([bring-up log §12](hardware/fab/test/BRINGUP-LOG-0001.md)).
> **Not yet done:** after a CAN cable pull the CAN side stayed deaf until the
> board was reset. A fix exists in development firmware, but it is not yet in
> this repository or any release, and has not been re-run on a board. LAN pulls,
> amplifier power cycles and long runs are untested, and only one board has been
> tried. Treat it as a development platform, not show equipment.
>
> **CANary Dev Edition (rev B)** is designed and routed (DRC 0 errors, 0
> unconnected) and its fab packages are made, but it has **never been ordered,
> built or powered**. Nothing about rev B, PoE included, is proven on hardware.

## Two variants

One design, two boards. Rev B is rev A with additions: the same ESP32-S3, W5500,
isolated CAN, USB-C PD input and three etherCONs, with a few parts swapped for
PoE (below). It is generated from rev A's routed board, keeping rev A's routing
and checking it is still on the expected nets ([REV-B.md](hardware/rev-b/REV-B.md)).

| | **CANary** (rev A) | **CANary Dev Edition** (rev B) |
|---|---|---|
| In short | the simple board: self-contained, made for the desktop tube case | rev A with its insides brought out, for a 1U rack box or an enclosure of your own |
| Files | [`hardware/`](hardware/) | [`hardware/rev-b/`](hardware/rev-b/REV-B.md), and the front-panel board in [`hardware/frontpanel/`](hardware/frontpanel/README.md) |
| Board | 100 × 81 mm, 4 layers | the same outline and stackup |
| Power | USB-C PD, 5 V | 802.3af PoE (SDAPO DP9900M-5V module) or a 5 V aux input (DNP pads), either taking priority over USB-C PD through a TPS2116 power mux |
| Module | ESP32-S3-WROOM-1-N8, no PSRAM | ESP32-S3-WROOM-1-N8R2, 2 MB of quad PSRAM (no firmware uses it yet) |
| Front panel | the board's own LEDs and buttons, through the case | keyed 16-way header J501: buffered LED sinks, RESET, BOOT, I2C, two spare GPIOs. A separate 84 × 26 mm front-panel board takes it on a ribbon |
| Extra pads (DNP) | none | CAN bus, remote termination switch, USB data, 5 V aux in |
| Ethernet magnetics | PT61017PEL | B1608S (PoE+ rated, same footprint); Bob Smith termination DC-blocked so PoE detection can work |
| Mounting | none: the board slides into the case's rails | four M3 holes |
| Status | built; board #1 works (above) | designed, routed, fab packages made; never ordered, built or powered |

The LEDs and buttons are on the same GPIOs on both, so today's firmware images
should run on rev B unchanged; with no rev B board, that has not been tried. To
build one now, build rev A. Rev B is for anyone who needs PoE, a rack front
panel or the spare I/O and is willing to go first: read REV-B.md's
[checks before ordering](hardware/rev-b/REV-B.md#what-to-check-before-ordering)
before spending anything. The PoE module's footprint, for one, has not been
compared with a real module.

## What is in this repo

| Path | What |
|---|---|
| [`hardware/`](hardware/) | Rev A board (**CANary**): KiCad 10 project (4 sheets, 100 × 81 mm, 4 layers), symbol/footprint library, fab outputs (Gerbers, BOM, pick-and-place, interactive BOM) and the design scripts that placed and routed it |
| [`hardware/rev-b/`](hardware/rev-b/) | Rev B board (**CANary Dev Edition**): KiCad 10 project (5 sheets), generic and JLCPCB fab packages, the scripts that generate it from rev A's board, and the write-up, [REV-B.md](hardware/rev-b/REV-B.md) |
| [`hardware/frontpanel/`](hardware/frontpanel/) | The Dev Edition's rack front-panel board (84 × 26 mm, 2 layers): four LEDs, RESET and BOOT on a 16-way ribbon, with its fab files and a panel drilling drawing |
| [`hardware/fab/test/`](hardware/fab/test/) | Bench bring-up procedure, functional test spec, probe points, and the bring-up log of board #1 |
| [`hardware/enclosure/`](hardware/enclosure/) | The one-piece **tube** case: parametric generator (CadQuery), STEP and STL for the body, end plates, LED window insert and switch cover, ready-sliced Bambu Lab plates, a jig for pressing the heat-set inserts, and a 2U [rack panel](hardware/enclosure/rack/README.md) that holds a tube in a collar (19-inch or 10-inch) |
| [`firmware/`](firmware/) | ESP-IDF 5.5 firmware: the Ethernet bridge, discovery responder, CAN at dbCAN's fixed 100 kbit/s, status LEDs, and an optional USB network device with an on-device settings page |
| [`tools/`](tools/) | Python reference implementation of the protocol, a host-side emulator you can point R1 at with no hardware, and the board acceptance test |
| [`docs/`](docs/) | Protocol reference, user guide, API, design decisions, fab notes |

## How it works

The R70 is a transparent bridge. It does not interpret d&b's amplifier
parameters, it carries CAN frames. Its Ethernet side speaks the **RM Byte
Command Protocol**, which RM Michaelides (now Proemion) publish. R1 finds
interfaces with a small UDP discovery exchange on port 33333, documented here
from captures of R1's discovery traffic and confirmed live. CANary implements
both, and nothing else. It has no knowledge of amplifier parameters and needs
none.

| | |
|---|---|
| Data socket | TCP **30000**, RM Byte Command Protocol |
| Discovery | UDP **33333** ([PROTOCOL.md §4](docs/PROTOCOL.md)) |
| CAN | dbCAN: CAN 2.0A, 11-bit IDs, **100 kbit/s fixed** |

Every claim in [docs/PROTOCOL.md](docs/PROTOCOL.md) is tagged `[spec]`,
`[derived]` or `[unknown]`, so you can tell what comes from a published
document and what is inferred.

## Getting started

**Flash a board from the browser.** The [CANary Flasher](https://canary-flasher.stoatworks-labs.com)
writes the current release over Web Serial (Chrome/Edge). Pick *Standard*
(Ethernet only), or *USB network + config page*, which also makes the unit a USB
network adapter at `192.168.7.1` with a settings page.

**Build the firmware yourself:**

```bash
. ~/esp/esp-idf/export.sh            # ESP-IDF v5.5
cd firmware
idf.py -B build -DSDKCONFIG=build/sdkconfig build
idf.py -B build -p /dev/cu.usbmodem* flash monitor
```

The USB network image is an overlay:
`-DSDKCONFIG_DEFAULTS="sdkconfig.defaults;sdkconfig.usb-ncm"` with its own `-B`
and `-DSDKCONFIG`. Without `-DSDKCONFIG` the overlay is silently ignored. See
[docs/DEVELOPING.md](docs/DEVELOPING.md).

**Try it against R1 with no hardware at all:**

```bash
python3 tools/r70_emu.py serve --answer-from <your LAN address>
```

In R1, go **Offline**, tick the interface's activation checkbox, and go back
**Online**. The checkbox is greyed out while Online.

**Build a board.** Rev A's fab outputs are in [`hardware/fab/`](hardware/fab/). Read
[`hardware/fab/test/BENCH-BRINGUP.md`](hardware/fab/test/BENCH-BRINGUP.md) §0
before powering one. The three etherCONs are physically identical and two of
them are CAN. Rev A has no PoE, and a passive PoE injector will destroy it.
Rev B's packages are in [`hardware/rev-b/fab/`](hardware/rev-b/fab/) and the
front panel's in [`hardware/frontpanel/fab/`](hardware/frontpanel/fab/). Neither
has been ordered yet.

**Print a case.** [`hardware/enclosure/`](hardware/enclosure/). The body prints
standing on its end in ABS-GF with no support (about 5 h and 131 g with both end plates,
on a 0.4 mm nozzle). The LED window inserts and switch covers are white PLA.
To rack one, [`hardware/enclosure/rack/`](hardware/enclosure/rack/README.md) has a 2U
panel that holds the tube whole in a collar, with a flat blank to each side: 19-inch in
three pieces that bolt together, or 10-inch in one. Not printed yet.

Full instructions: [docs/USER-GUIDE.md](docs/USER-GUIDE.md).

## Tests

```bash
python3 -m venv .venv && ./.venv/bin/pip install pytest
./run_tests.sh      # Python reference, C firmware components on the host, fuzzers
```

The firmware's protocol components are ESP-IDF-free, so they compile and run on
the host against the same test vectors as the Python reference. Those vectors
come from the vendor's worked examples and from real captures. When extending
the protocol, add vectors from a document or a capture: a test that encodes
your own assumption proves nothing.

## Roadmap

- [x] CAN on a real amplifier bus, and R1 driving amplifiers through the board —
      board #1, 2026-10-28 ([bring-up log §12](hardware/fab/test/BRINGUP-LOG-0001.md)),
      with one fault: the CAN side did not recover from a cable pull until reset
- [ ] Recovery after a CAN cable pull, on a board (fixed in development firmware, not yet
      here); amplifier power cycles, LAN pulls and long runs
- [ ] R1 discovering a unit over USB; Windows hosts for the USB network image
- [ ] CANary Dev Edition (rev B) on hardware: designed, routed and packaged with PoE, the
      front-panel header, port pads and mounting holes, never ordered. First the
      [checks before ordering](hardware/rev-b/REV-B.md#what-to-check-before-ordering),
      then a build and a bring-up
- [ ] Ethernet ESD/TVS and silkscreen cleanup: not done in rev B either
- [ ] R60-compatible USB serial mode

Issues and pull requests are welcome, especially bench results from anyone with
a D6/D12/E-PAC rig.

## Licence

Board: **CERN-OHL-S-2.0** · Enclosure and docs: **CC BY-SA 4.0** · Firmware and
tools: **MIT**. See [LICENSE](LICENSE) for which applies to what, and for the
exceptions (fonts, the Stoatworks Labs mark).

## Disclaimer

CANary is an independent implementation, built from published documentation
and observed network traffic. It contains no d&b audiotechnik or RM Michaelides
code or firmware. Vendor manuals are not redistributed here; see
[docs/SOURCES.md](docs/SOURCES.md) for where to get them.

"d&b audiotechnik", "R1", "R70" and "dbCAN" are trademarks of d&b audiotechnik
GmbH & Co. KG, used only to describe compatibility. This project is not
affiliated with, endorsed by, or supported by d&b audiotechnik or Proemion.
Using it with d&b equipment is at your own risk, and may affect that
equipment's warranty or support status.

## KiCad design hardware/frontpanel/canary-fp.kicad_pcb

File hardware/frontpanel/README.md:

# CANary front panel

> **Status (2026-10-29): designed, routed, fab files made; never ordered or built.** DRC is
> clean with schematic parity on. The panel it sits behind has not been drawn beyond the
> drilling drawing here.

The front panel for a rack-mounted CANary: the four status LEDs and the RESET and BOOT
buttons, on an 84 x 26 mm board behind a 1U panel, fed by a 16-way ribbon from a rev B main
board's J501. Pinout and what each line does: [`../rev-b/REV-B.md`](../rev-b/REV-B.md).

| | |
|---|---|
| LEDs | D1 ON, D2 LAN, D3 CAN (green), D4 ERR (red), 3 mm, anode from FP_5V through 1 k |
| Buttons | SW2 BOOT, SW1 RESET, 6 mm tact switches |
| J1 | 2x8 IDC box header on the back, pin 1 = FP_5V |
| J2 (DNP) | 3V3, GND, SDA, SCL, FN1, FN2 for a display or more buttons |
| Holes | four M3, copper kept 3.6 mm clear, for standoffs to the panel |

The LEDs light exactly when the board's own do: the main board sinks each cathode with an
open-drain buffer. 1 k gives about 3 mA, dim on purpose for dark venues. Lower it for
brighter, 20 mA at most per line.

## Fitting it behind a panel

Board stood off 7 mm behind a 2 mm panel (M3 standoffs on the four holes).

- **LEDs**: raise them on 4 mm spacers so the dome sits in the 3.2 mm panel hole.
- **BOOT** is the 9.5 mm-tall switch: it stands 0.5 mm proud of the panel face.
- **RESET** is the 7.3 mm one: 1.7 mm behind the face, through a 2.5 mm hole, so it takes a
  pin or a paperclip and not a stray elbow.
- Hold BOOT and tap RESET for the ROM download mode. At run time BOOT is free for firmware
  (GPIO0); nothing uses it yet.

`fab/panel.dxf` and `fab/panel.pdf` are the drilling drawing: every panel hole at its place
relative to the board outline, drawn on Dwgs.User.

## Building it

```sh
<kicad python> hardware/frontpanel/scripts/build.py   # board from the schematic, routed, DRC
hardware/frontpanel/scripts/fab.sh                    # Gerbers, drill, BOM, CPL, panel drawing
```

`<kicad python>` is `/Applications/KiCad/KiCad.app/Contents/Frameworks/Python.framework/Versions/3.9/bin/python3`.
The board is generated, so GUI edits are lost on the next build. Freerouting is not
deterministic; `build.py` routes again until DRC is clean. The BOM leaves out the holes and
anything with `Fit=DNP` (J2). Rev A's convention, since Konnect cannot set KiCad's DNP flag.

Parts:
C1, C2: 100nF; C_0603_1608Metric
D1: ON green; LED_D3.0mm
D2: LAN green; LED_D3.0mm
D3: CAN green; LED_D3.0mm
D4: ERR red; LED_D3.0mm
H1, H2, H3, H4: M3; MountingHole_3.2mm_M3
J1: FROM MAIN J501; IDC-Header_2x08_P2.54mm_Vertical
J2: EXTRA; PinHeader_1x06_P2.54mm_Vertical
R1, R2, R3, R4: 1k; R_0603_1608Metric
SW1: RESET; SW_PUSH_6mm_H7.3mm
SW2: BOOT; SW_PUSH_6mm_H9.5mm

Connections:
/FP_3V3: C2.1, J1.2, J2.1
/FP_5V: C1.1, J1.1, R1.1, R2.1, R3.1, R4.1
/FP_BOOT_N: J1.10, SW2.1
/FP_CAN_N: D3.1 (K), J1.7
/FP_ERR_N: D4.1 (K), J1.8
/FP_FN1: J1.15, J2.5
/FP_FN2: J1.16, J2.6
/FP_LAN_N: D2.1 (K), J1.6
/FP_ON_N: D1.1 (K), J1.5
/FP_RESET_N: J1.9, SW1.1
/FP_SCL: J1.14, J2.4
/FP_SDA: J1.13, J2.3
/GND: C1.2, C2.2, J1.3, J1.4, J1.11, J1.12, J2.2, SW1.2, SW2.2
/LED_CAN_A: D3.2 (A), R3.2
/LED_ERR_A: D4.2 (A), R4.2
/LED_LAN_A: D2.2 (A), R2.2
/LED_ON_A: D1.2 (A), R1.2

Notes on the sheet:
CANary front panel (rack variant). J1 takes a 16-way ribbon from the main board's J501. LEDs: anode from FP_5V through R1-R4, cathode into the main board's open-drain sinks, so each lights exactly when its board LED does. 1k gives ~3 mA: dim on purpose, for dark venues. Lower R for brighter (20 mA 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

Board: 2 copper layers, 84.0 x 26.0 mm, 18 parts (1 on the bottom side), 17 nets.

File hardware/frontpanel/fab/bom.csv:

Designators,Qty,Value,Footprint
"C1,C2",2,100nF,Capacitor_SMD:C_0603_1608Metric
D1,1,ON green,LED_THT:LED_D3.0mm
D2,1,LAN green,LED_THT:LED_D3.0mm
D3,1,CAN green,LED_THT:LED_D3.0mm
D4,1,ERR red,LED_THT:LED_D3.0mm
J1,1,FROM MAIN J501,Connector_IDC:IDC-Header_2x08_P2.54mm_Vertical
R1-R4,4,1k,Resistor_SMD:R_0603_1608Metric
SW1,1,RESET,Button_Switch_THT:SW_PUSH_6mm_H7.3mm
SW2,1,BOOT,Button_Switch_THT:SW_PUSH_6mm_H9.5mm

## KiCad design hardware/rev-b/canary.kicad_pcb

File hardware/README.md (part):

# CANary hardware

KiCad 10 project for the R70-compatible IP-to-CAN bridge.
Architecture and the reasoning behind every part choice: [../docs/DECISIONS.md](../docs/DECISIONS.md) (H1–H19).

The KiCad files in this folder are **rev A** (**CANary**), the board that was built.
**Rev B** (**CANary Dev Edition**: front-panel header, port pads, PoE with a priority power
mux, mounting holes, the N8R2 module) is in [`rev-b/`](rev-b/REV-B.md), and the rack
front-panel board that goes with it is in [`frontpanel/`](frontpanel/README.md). Both are
designed, routed and packaged for fab, and neither has been ordered, built or powered.
Both use the symbol and footprint library in [`lib/`](lib/).

> ## ⚠ Written at the schematic stage
>
> This README is from before layout, and before PoE was dropped from rev A, so its status and
> the PoE parts of the Power and Ethernet sections are out of date. Where it disagrees with the
> board files, the board files win:
>
> | This README says | Rev A as built |
> |---|---|
> | PCB not started; nothing laid out, routed, DRC'd or fabricated | routed with DRC 0 errors and 0 unconnected, and built turnkey from `d9a725d` ([`../docs/FAB.md`](../docs/FAB.md)) |
> | PoE + USB-C, OR'd by Schottky; U101 still to place | USB-C PD only. PoE is deferred to rev B (DECISIONS.md H19), U101 isn't fitted and the OR-ing diodes are gone (H19a) |
> | etherCON footprint is a placeholder | `canary:Neutrik_etherCON_NE8FBH` on J201, J202 and J401 |
> | `POE_MODEA_*` / `POE_MODEB_*` nets | `ETH_CT_TD` / `ETH_CT_RD` / `ETH_SPARE_1/2` (H19c) |
>
> For the board as built, see [`../docs/FAB.md`](../docs/FAB.md) and
> [`fab/test/BRINGUP-LOG-0001.md`](fab/test/BRINGUP-LOG-0001.md).

## Status

| Sheet | File | State |
|---|---|---|
| Root | `canary.kicad_sch` | 4 sheets placed, CAN sheet pins linked |
| Power — PoE + USB-C, 5 V / 3V3 | `power.kicad_sch` | **drawn**, 15 symbols, 0 unconnected pins (U101 pending, see below) |
| MCU — ESP32-S3-WROOM-1, USB, LEDs | `mcu.kicad_sch` | **drawn**, 17 symbols, 0 unconnected pins |
| Ethernet — W5500 SPI, PoE tap, etherCON | `ethernet.kicad_sch` | **drawn**, 18 symbols, 0 unconnected pins |
| dbCAN — ADM3053 isolated | `can.kicad_sch` | **drawn**, 16 symbols, 0 unconnected pins |
| PCB | `canary.kicad_pcb` | **not started** |

**All four sheets are drawn** — 68 symbols, 0 unconnected pins on every sheet, and
the exported netlist confirms every cross-sheet bus connects. One part is still
missing (U101, see below).

**All 68 symbols have footprints assigned** — except that the three etherCON jacks
carry a deliberate placeholder (see below).

Nothing has been laid out, routed, DRC'd or fabricated.

> ### ⚠ etherCON footprint is a placeholder
> J201/J202/J401 use `Connector_RJ:RJ45_OST_PJ012-8P8CX_Vertical` so the netlist
> imports and layout can begin. **It is not an NE8FBH and must be replaced before
> fab.** KiCad ships no Neutrik etherCON footprint; it has to be drawn from the
> NE8FBH datasheet.
>
> Also note the variant correction: **NE8FDP cannot be used.** It is a panel-mount
> *feedthrough* whose rear is a female RJ45 socket — it does not solder to a PCB,
> and would need an internal patch lead per connector. NE8FBH is the horizontal
> PCB-mount part. See DECISIONS.md H6a.

## Architecture pivot (2026-07-23) — read this first

The MCU changed from **classic ESP32 + LAN8720 RMII** to **ESP32-S3 + W5500 SPI**,
and the barrel jack is gone. Full reasoning in `../docs/DECISIONS.md` H14–H18.

The trigger: the classic ESP32 has **no native USB peripheral**. It is UART-only,
so it physically cannot present as a USB network adapter or emulate an R60 — both
of which the S3 makes possible, while also deleting the USB-UART programming
bridge. The S3 has no EMAC, so RMII gives way to W5500-over-SPI; at dbCAN's
100 kbit/s that is ample, and it removes the 50 MHz oscillator and the
length-matched RMII group, previously the most EMC-critical things on the board.

Verified before committing to it, not assumed: `esp_eth_mac_w5500.c` ships in the
installed ESP-IDF v5.5.5, `tusb_ncm` is an official example listing ESP32-S3 as
supported, and the S3's `soc_caps.h` confirms TWAI and USB-OTG.

## ERC

**6 errors, all the same expected cause:** `power_pin_not_driven` on the rails,
because U101 is not placed and there are no `PWR_FLAG`/power symbols yet.

**Deliberately not silenced with PWR_FLAG.** Those flags would equally hide a
genuinely undriven rail. They should clear once U101 lands and the rails are
driven; if they don't, that is a real finding rather than a formality.

Warnings that remain are cosmetic: `same_local_global_label` where a local label
on a component pin shares a name with a global rail (connectivity is correct —
KiCad merges them), and `isolated_pin_label` on nets whose other end lives on the
still-empty Ethernet sheet (`SPI_*`, `ETH_*`, `POE_*`).

### A trap worth knowing

Deleting a component does **not** delete the net labels `batch_connect_to_net`
placed at its pins. Those orphans linger and ERC surfaces them one at a time, so
it looks like whack-a-mole. Worse, one of them was a genuine short: a leftover
`V5_DC` label from the deleted wide-Vin buck ended up co-located with `VBUS` on
the new USB OR diode, and ERC reported `multiple_net_names` — USB VBUS would have
been silently renamed to the old buck's output net. **After deleting parts, sweep
their pin coordinates for orphaned labels rather than trusting the delete.**

## What the Power sheet encodes

Two sources, OR'd by Schottky into `VCC_5V` — **no barrel jack**:

- **PoE** → Ag97005-FL (U101) → `POE_5V` → D104 → `VCC_5V`
- **USB-C** → `VBUS` → F101 (PTC) → D103 → `VCC_5V`

Both give 5 V directly, so there is no wide-Vin buck and no intermediate rail —
that whole chain (12 parts) was deleted in the pivot. `VCC_5V` feeds the ADM3053
and U103, the only remaining converter (5 V → 3V3).

**USB-PD is real**, not a passive sink: U104 is a **CH224K** negotiating over
CC1/CC2. It happens to be in KiCad's stock `Interface_USB` library, so no custom
symbol and no library-cache blocker.

> ### ⚠ CFG1 is safety-critical
> The CH224K picks its requested voltage from the CFG1/2/3 levels, and the
> datasheet warns it requests **20 V if CFG1 floats at power-up**. This board
> cannot survive that — 20 V would pass D103 straight onto `VCC_5V` and destroy
> the ADM3053 (VCC abs max ~6 V) and U103's input.
>
> CFG1 is therefore **hard-tied to `PD_VDD` in copper, not driven by an MCU GPIO**.
> It could not be a GPIO even in principle: the MCU is powered *from* this rail,
> so it cannot configure the PD chip before the rail it depends on exists.

The 5.1 k Rd pulldowns were removed — the CH224K drives CC itself, and fixed
resistors in parallel would present the wrong impedance and break PD signalling.
CH224K DP/DM are deliberately unconnected: they serve legacy BC1.2/QC, and wiring
them to the data pair would corrupt the USB link needed for NCM/R60/programming.

We request **5 V**, not a higher PD voltage, because 5 V feeds the ADM3053
directly — asking for 9 V or 12 V would reintroduce the wide-Vin buck H17 deleted.

Both bucks use the **adjustable** AP63200WU rather than the fixed AP63205/AP63203
variants: those are `extends` aliases that Konnect resolves to zero pins.

## What the Ethernet sheet encodes

**etherCON has no magnetics.** A Neutrik etherCON is a rugged *shell* around a
plain RJ45, so unlike the usual "HR911105A magjack" design the transformer must be
a separate part — T401 (PT61017PEL, 10/100 with centre taps). Chain: J401 →
T401 line side → T401 PHY side → W5500.

PoE is tapped here and powered on the Power sheet: **Mode A** from the T401 centre
taps, **Mode B** from J401 pins 4/5 and 7/8. All four go to U101's VINA–VIND,
whose internal bridge rectifiers make them polarity-insensitive — which is why
there is no external diode bridge and why both modes work without a jumper.

> ⚠ `POE_MODEA_*` and `POE_MODEB_*` sit at **up to 57 V** relative to GND. They are

Parts:
C105: 100nF (BST); C_0402_1005Metric
C106: 22uF 16V; C_0805_2012Metric
C107: 10uF 16V; C_0805_2012Metric
C108: 100nF; C_0402_1005Metric
C109: 1uF; C_0402_1005Metric
C110, C111, C112: 1uF; C_0402_1005Metric; MPN CL05A105KA5NQNC; LCSC C52923
D105: SMF5.0A; D_SOD-123F; MPN SMF5.0A; LCSC C193402
F101: PTC 1.1A; Fuse_1206_3216Metric
F102: PTC 1.1A; Fuse_1206_3216Metric; MPN BSMD1206-110-30V; LCSC C21714343
J102: USB-C 16P; USB_C_Receptacle_HRO_TYPE-C-31-M-12
J103: 5V AUX IN; PinHeader_1x02_P2.54mm_Vertical
L102: 2.2uH 2A; L_Bourns-SRN4018
R103: 31.6k 1%; R_0402_1005Metric
R104: 10k 1%; R_0402_1005Metric
R106: 1k; R_0402_1005Metric
R107: 10k; R_0402_1005Metric
R108: 100k; R_0402_1005Metric; MPN 0402WGF1003TCE; LCSC C25741
R109: 33k; R_0402_1005Metric; MPN 0402WGF3302TCE; LCSC C25779
U103: AP63200WU; TSOT-23-6
U104: CH224K; SSOP-10-1EP_3.9x4.9mm_P1mm_EP2.1x3.3mm
U105: TPS2116; SOT-583-8; MPN TPS2116DRLR; LCSC C3235557
U106: LM66100; SOT-363_SC-70-6; MPN LM66100DCKR; LCSC C2869734

Connections:
/Power — PoE + USB-C PD, 5V and 3V3/AUX_FUSED: C111.1, D105.1 (K), F102.2, U106.1 (VIN)
/Power — PoE + USB-C PD, 5V and 3V3/BST2: C105.2, U103.6 (BST)
/Power — PoE + USB-C PD, 5V and 3V3/FB2: R103.2, R104.1, U103.1 (FB)
/Power — PoE + USB-C PD, 5V and 3V3/MUX_PR1: R108.2, R109.1, U105.4 (PR1)
/Power — PoE + USB-C PD, 5V and 3V3/PD_VBUS_SENSE: R107.2, U104.8 (VBUS)
/Power — PoE + USB-C PD, 5V and 3V3/PD_VDD: C109.1, R106.2, U104.1 (VDD), U104.9 (CFG1)
/Power — PoE + USB-C PD, 5V and 3V3/SW2: C105.1, L102.1, U103.5 (SW)
/Power — PoE + USB-C PD, 5V and 3V3/USB_CC1: J102.A5 (CC1), U104.7 (CC1)
/Power — PoE + USB-C PD, 5V and 3V3/USB_CC2: J102.B5 (CC2), U104.6 (CC2)
/Power — PoE + USB-C PD, 5V and 3V3/VBUS_FUSED: C110.1, F101.2, R106.1, R107.1, U105.6 (VIN2)
/Power — PoE + USB-C PD, 5V and 3V3/VBUS_RAW: F101.1, J102.A4 (VBUS), J102.A9 (VBUS), J102.B4 (VBUS), J102.B9 (VBUS)
/Power — PoE + USB-C PD, 5V and 3V3/VIN_AUX: F102.1, J103.1
CHASSIS: J102.SH (SHIELD); also elsewhere on the board
EXT_5V: C112.1, R108.1, U105.3 (VIN1), U105.5 (MODE), U106.6 (VOUT); also elsewhere on the board
GND: C106.2, C107.2, C108.2, C109.2, C110.2, C111.2, C112.2, D105.2 (A), J102.A1 (GND), J102.A12 (GND), J102.B1 (GND), J102.B12 (GND), J103.2, R104.2, R109.2, U103.4 (GND), U104.11 (GND), U105.1 (GND), U106.2 (GND), U106.3 (~CE); also elsewhere on the board
PD_PG: U104.10 (PG); also elsewhere on the board
USB_DM: J102.A7 (D-), J102.B7 (D-); also elsewhere on the board
USB_DP: J102.A6 (D+), J102.B6 (D+); also elsewhere on the board
VCC_3V3: C106.1, L102.2, R103.1; also elsewhere on the board
VCC_5V: C107.1, C108.1, U103.2 (EN), U103.3 (IN), U105.2 (VOUT), U105.7 (VOUT); also elsewhere on the board

Notes on the sheet:
ONE POWER SOURCE IN REV A: USB-C PD ONLY — no barrel jack, no PoE. USB-C: VBUS -> F101 (PTC) -> VCC_5V — direct, no OR-ing diode. PD negotiates 5V at the connector, so there is no wide-Vin buck and no intermediate rail. VCC_5V feeds the ADM3053 and U103 (5V -> 3V3 for the S3, W5500 and ADM3053 VIO)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
POE IS DEFERRED TO REV B — BY DECISION (H19, 2026-07-25), NOT BY A TOOLING FAULT. Rev A is USB-C PD only. The Ag97005-FL module was this board's risk concentration: 56 x 14 mm on a board meant to be as small as practical, NOT on LCSC so JLCPCB cannot assemble it, hand-soldered, and its land pattern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
REV B: VCC_5V comes from U105, a TPS2116 power mux with priority: VIN1 = EXT_5V: the PoE module (U402, Ethernet sheet) OR the 5 V AUX IN through U106 (LM66100). Both are external supplies, so either beats USB. MODE tied to VIN1; R108/R109 put PR1 at VREF (1.0 V) when EXT_5V falls to ~4.0 V (3.7-4.4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

Parts:
C301: 22uF; C_0805_2012Metric
C302, C303, C304: 100nF; C_0402_1005Metric
D301: LAN (green); LED_0603_1608Metric
D302: ERR (red); LED_0603_1608Metric
D303: CAN (green); LED_0603_1608Metric
D304: ON (green); LED_0603_1608Metric
J301: UART/debug 1.27mm; PinHeader_1x06_P1.27mm_Vertical
R301: 10k; R_0402_1005Metric
R302, R303, R304, R305: 1k; R_0402_1005Metric
SW301: RESET; SW_SPST_PTS645Sx43SMTR92
SW302: BOOT; SW_SPST_PTS645Sx43SMTR92
U301: ESP32-S3-WROOM-1-N8R2; ESP32-S3-WROOM-1; MPN ESP32-S3-WROOM-1-N8R2; LCSC C2913204

Connections:
/MCU — ESP32-S3-WROOM-1, USB, LEDs/LED_CAN_A: D303.2 (A), R304.2
/MCU — ESP32-S3-WROOM-1, USB, LEDs/LED_ERR_A: D302.2 (A), R303.2
/MCU — ESP32-S3-WROOM-1, USB, LEDs/LED_LAN_A: D301.2 (A), R302.2
/MCU — ESP32-S3-WROOM-1, USB, LEDs/LED_ON_A: D304.2 (A), R305.2
/MCU — ESP32-S3-WROOM-1, USB, LEDs/UART0_RXD: J301.4, U301.36 (RXD0)
/MCU — ESP32-S3-WROOM-1, USB, LEDs/UART0_TXD: J301.3, U301.37 (TXD0)
BOOT: J301.5, SW302.1, U301.27 (IO0); also elsewhere on the board
CAN_RX: U301.5 (IO5); also elsewhere on the board
CAN_TX: U301.4 (IO4); also elsewhere on the board
EN: C304.1, J301.6, R301.2, SW301.1, U301.3 (EN); also elsewhere on the board
ETH_CSn: U301.18 (IO10); also elsewhere on the board
ETH_INTn: U301.22 (IO14); also elsewhere on the board
ETH_RSTn: U301.17 (IO9); also elsewhere on the board
FN1: U301.31 (IO38); also elsewhere on the board
FN2: U301.32 (IO39); also elsewhere on the board
GND: C301.2, C302.2, C303.2, C304.2, D301.1 (K), D302.1 (K), D303.1 (K), D304.1 (K), J301.2, SW301.2, SW302.2, U301.1 (GND), U301.40 (GND), U301.41 (GND); also elsewhere on the board
I2C_SCL: U301.38 (IO2); also elsewhere on the board
I2C_SDA: U301.39 (IO1); also elsewhere on the board
LED_CAN: R304.1, U301.10 (IO17); also elsewhere on the board
LED_ERR: R303.1, U301.9 (IO16); also elsewhere on the board
LED_LAN: R302.1, U301.8 (IO15); also elsewhere on the board
PD_PG: U301.11 (IO18); also elsewhere on the board
SPI_MISO: U301.21 (IO13); also elsewhere on the board
SPI_MOSI: U301.19 (IO11); also elsewhere on the board
SPI_SCK: U301.20 (IO12); also elsewhere on the board
USB_DM: U301.13 (USB_D-); also elsewhere on the board
USB_DP: U301.14 (USB_D+); also elsewhere on the board
VCC_3V3: C301.1, C302.1, C303.1, J301.1, R301.1, R305.1, U301.2 (3V3); also elsewhere on the board

Notes on the sheet:
ESP32-S3-WROOM-1 PIN MAP — keep firmware (components/dbcan, net, bridge) in step. USB D+ = IO20, D- = IO19 FIXED IN SILICON, not reassignable. The symbol names them USB_D+/USB_D-. TWAI/CAN CAN_TX = IO4, CAN_RX = IO5 -> ADM3053 on the dbCAN sheet W5500 SCK=IO12 MOSI=IO11 MISO=IO13 CSn=IO10 INTn=IO14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
