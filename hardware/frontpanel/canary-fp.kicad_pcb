# Repository stoatworks-labs/canary (continued)

## KiCad design hardware/rev-b/canary.kicad_pcb (continued)

Parts:
C401, C402: 18pF; C_0402_1005Metric
C403: 10uF; C_0805_2012Metric
C404, C405, C406, C407: 100nF; C_0402_1005Metric
C408: 4.7uF (1V2O); C_0603_1608Metric
C409: 100nF (VBG); C_0402_1005Metric
C410: 4.7uF (TOCAP); C_0603_1608Metric
C411: 1nF 2kV; C_1206_3216Metric
C412: 10nF (TCT); C_0402_1005Metric
C413: 6.8nF (RCT); C_0402_1005Metric
C414, C415, C416, C417: 10nF 100V; C_0402_1005Metric; MPN CC0402KRX7R0BB103; LCSC C527014
C418: 47uF; C_1206_3216Metric; MPN CL31A476MPHNNNE; LCSC C96123
C419: 100nF; C_0402_1005Metric; MPN CL05B104KO5NNNC; LCSC C1525
D401, D402: MB10S; TO-269AA; MPN MB10S-50MIL; LCSC C2488
D403: SMAJ58A; D_SMA; MPN SMAJ58A; LCSC C123816
J401: etherCON NE8FBH LAN; Neutrik_etherCON_NE8FBH
R401: 12.4k 1%; R_0402_1005Metric
R402, R403, R404, R405: 75R; R_0603_1608Metric
R406, R407, R408, R409: 49.9R 1%; R_0402_1005Metric
R410: 10R 1%; R_0402_1005Metric
R411: 1M; R_0402_1005Metric
R412: 0R (XO series); R_0402_1005Metric
R413: 10k; R_0402_1005Metric; MPN 0402WGF1002TCE; LCSC C25744
T401: B1608S; Transformer_Ethernet_Bourns_PT61017PEL; MPN B1608S; LCSC C507596
U401: W5500; LQFP-48_7x7mm_P0.5mm
U402: DP9900M-5V; SDAPO_DP9900M; MPN DP9900M-5V; LCSC C5380106
Y401: 25MHz 10ppm; Crystal_SMD_3225-4Pin_3.2x2.5mm

Connections:
/Ethernet — W5500 SPI, PoE magjack, etherCON/BOB_SMITH: C411.1, C414.2, C416.2, C417.2, R403.2
/Ethernet — W5500 SPI, PoE magjack, etherCON/BS_RD: C415.1, R403.1
/Ethernet — W5500 SPI, PoE magjack, etherCON/BS_SPARE_1: C416.1, R404.2
/Ethernet — W5500 SPI, PoE magjack, etherCON/BS_SPARE_2: C417.1, R405.2
/Ethernet — W5500 SPI, PoE magjack, etherCON/BS_TD: C414.1, R402.2
/Ethernet — W5500 SPI, PoE magjack, etherCON/ETH_1V2: C408.1, U401.22 (1V2O)
/Ethernet — W5500 SPI, PoE magjack, etherCON/ETH_CT_RD: C415.2, D401.3, T401.7 (C_RD)
/Ethernet — W5500 SPI, PoE magjack, etherCON/ETH_CT_TD: D401.4, R402.1, T401.2 (C_TD)
/Ethernet — W5500 SPI, PoE magjack, etherCON/ETH_EXRES: R401.1, U401.10 (EXRES1)
/Ethernet — W5500 SPI, PoE magjack, etherCON/ETH_RCT: C413.1, R408.2, R409.2, T401.10 (C_RX)
/Ethernet — W5500 SPI, PoE magjack, etherCON/ETH_RXN: R409.1, T401.9 (RX-), U401.5 (RXN)
/Ethernet — W5500 SPI, PoE magjack, etherCON/ETH_RXP: R408.1, T401.11 (RX+), U401.6 (RXP)
/Ethernet — W5500 SPI, PoE magjack, etherCON/ETH_SPARE_1: D402.3, J401.4, J401.5, R404.1
/Ethernet — W5500 SPI, PoE magjack, etherCON/ETH_SPARE_2: D402.4, J401.7, J401.8, R405.1
/Ethernet — W5500 SPI, PoE magjack, etherCON/ETH_TCT: C412.1, R406.2, R407.2, R410.2, T401.15 (C_TX)
/Ethernet — W5500 SPI, PoE magjack, etherCON/ETH_TOCAP: C410.1, U401.20 (TOCAP)
/Ethernet — W5500 SPI, PoE magjack, etherCON/ETH_TXN: R407.1, T401.14 (TX-), U401.1 (TXN)
/Ethernet — W5500 SPI, PoE magjack, etherCON/ETH_TXP: R406.1, T401.16 (TX+), U401.2 (TXP)
/Ethernet — W5500 SPI, PoE magjack, etherCON/ETH_VBG: C409.1, U401.18 (VBG)
/Ethernet — W5500 SPI, PoE magjack, etherCON/ETH_XI: C401.1, R411.1, U401.30 (XI/CLKIN), Y401.1
/Ethernet — W5500 SPI, PoE magjack, etherCON/ETH_XO: C402.1, R411.2, R412.2, Y401.2
/Ethernet — W5500 SPI, PoE magjack, etherCON/ETH_XO_DRV: R412.1, U401.31 (XO)
/Ethernet — W5500 SPI, PoE magjack, etherCON/LAN_RD_N: J401.6, T401.8 (RD-)
/Ethernet — W5500 SPI, PoE magjack, etherCON/LAN_RD_P: J401.3, T401.6 (RD+)
/Ethernet — W5500 SPI, PoE magjack, etherCON/LAN_TD_N: J401.2, T401.3 (TD-)
/Ethernet — W5500 SPI, PoE magjack, etherCON/LAN_TD_P: J401.1, T401.1 (TD+)
/Ethernet — W5500 SPI, PoE magjack, etherCON/POE_VN: D401.2 (-), D402.2 (-), D403.2 (A), U402.7 (VIN-), U402.8 (VIN-)
/Ethernet — W5500 SPI, PoE magjack, etherCON/POE_VP: D401.1 (+), D402.1 (+), D403.1 (K), U402.5 (VIN+), U402.6 (VIN+)
CHASSIS: C411.2, J401.SH; also elsewhere on the board
ETH_CSn: U401.32 (~SCS); also elsewhere on the board
ETH_INTn: U401.36 (~INT); also elsewhere on the board
ETH_RSTn: R413.2, U401.37 (~RST); also elsewhere on the board
EXT_5V: C418.1, C419.1, U402.1 (+VDC), U402.2 (+VDC); also elsewhere on the board
GND: C401.2, C402.2, C403.2, C404.2, C405.2, C406.2, C407.2, C408.2, C409.2, C410.2, C412.2, C413.2, C418.2, C419.2, R401.2, U401.3 (AGND), U401.9 (AGND), U401.14 (AGND), U401.16 (AGND), U401.19 (AGND), U401.29 (GND), U401.48 (AGND), U402.3 (-VDC); also elsewhere on the board
SPI_MISO: U401.34 (MISO); also elsewhere on the board
SPI_MOSI: U401.35 (MOSI); also elsewhere on the board
SPI_SCK: U401.33 (SCLK); also elsewhere on the board
VCC_3V3: C403.1, C404.1, C405.1, C406.1, C407.1, R410.1, R413.1, U401.4 (AVDD), U401.8 (AVDD), U401.11 (AVDD), U401.15 (AVDD), U401.17 (AVDD), U401.21 (AVDD), U401.28 (VDD), U401.43 (PMODE2), U401.44 (PMODE1), U401.45 (PMODE0); also elsewhere on the board

Notes on the sheet:
WHY DISCRETE MAGNETICS AND NOT A MAGJACK. Neutrik etherCON (H6) is a rugged SHELL around a plain RJ45 — it contains no magnetics at all. So unlike the usual "HR911105A magjack" design, the transformer has to be a separate part: T401 (PT61017PEL, 10/100 with centre taps). Chain: etherCON J401 -> T40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
R413 (rev B): holds the W5500 in a defined state while IO9 floats at reset (BENCH-BRINGUP 2.2.6).
REV B: PoE fitted (802.3af PD). This replaces the rev A PoE paragraph at left. U402 SDAPO DP9900M-5V: 5 V out as EXT_5V to the power mux (power sheet). D401 = mode A (T401 centre taps), D402 = mode B (spare pairs), D403 clamps. POE_VP/POE_VN sit up to 57 V apart and float against GND and CHASSIS: U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

Parts:
C201, C203, C204, C206: 100nF; C_0402_1005Metric
C202, C205: 10uF; C_0805_2012Metric
C207: 4.7nF; C_0603_1608Metric
D201: NUP2105L; SOT-23
FB201: 600R@100MHz; L_0603_1608Metric
J201: etherCON NE8FBH CAN A; Neutrik_etherCON_NE8FBH
J202: etherCON NE8FBH CAN B; Neutrik_etherCON_NE8FBH
J203: CAN BUS; PinHeader_1x03_P2.54mm_Vertical
J204: TERM REMOTE; PinHeader_1x03_P2.54mm_Vertical
R201: 0R; R_0402_1005Metric
R202, R203: 62R; R_0603_1608Metric
SW201: TERMINATE 120R; SW_DIP_SPSTx02_Slide_9.78x7.26mm_W7.62mm_P2.54mm
U201: ADM3053BRWZ; SOIC-20W_7.5x12.8mm_P1.27mm

Connections:
/dbCAN — ADM3053 isolated, 2x etherCON/CANH: D201.1 (K), J201.4, J202.4, J203.1, R202.1, U201.17 (CANH)
/dbCAN — ADM3053 isolated, 2x etherCON/CANL: D201.3 (A), J201.5, J202.5, J203.2, R203.2, U201.15 (CANL)
/dbCAN — ADM3053 isolated, 2x etherCON/CAN_GND: C204.2, C205.2, C206.2, C207.2, D201.2 (K), J201.SH, J202.SH, J203.3, R201.2, U201.11 (GND2), U201.13 (GND2), U201.16 (GND2), U201.20 (GND2)
/dbCAN — ADM3053 isolated, 2x etherCON/CAN_RS: R201.1, U201.18 (RS)
/dbCAN — ADM3053 isolated, 2x etherCON/TERM_A: J204.1, R202.2, SW201.3
/dbCAN — ADM3053 isolated, 2x etherCON/TERM_B: J204.3, R203.1, SW201.1
/dbCAN — ADM3053 isolated, 2x etherCON/TERM_MID: C207.1, J204.2, SW201.2, SW201.4
/dbCAN — ADM3053 isolated, 2x etherCON/VISO: C205.1, C206.1, FB201.2, U201.19 (VISOIN)
/dbCAN — ADM3053 isolated, 2x etherCON/VISO_RAW: C204.1, FB201.1, U201.12 (VISOOUT)
CAN_RX: U201.4 (RXD); also elsewhere on the board
CAN_TX: U201.5 (TXD); also elsewhere on the board
GND: C201.2, C202.2, C203.2, U201.1 (GND1), U201.3 (GND1), U201.7 (GND1), U201.9 (GND1), U201.10 (GND1); also elsewhere on the board
VCC_3V3: C203.1, U201.6 (VIO); also elsewhere on the board
VCC_5V: C201.1, C202.1, U201.8 (VCC); also elsewhere on the board

Notes on the sheet:
ISOLATION BARRIER — U201 separates GND (logic) from CAN_GND (bus). No copper on ANY layer may cross under the ADM3053: no pour, no plane, no stitching vias. CAN_GND must stay galvanically separate from GND everywhere.
dbCAN wiring per d&b TI 312: RJ45 pin 4 = CAN_H, pin 5 = CAN_L, SHELL = CAN ground (carried on the cable shield — shielded jacks are mandatory). J201/J202 are wired in PARALLEL so amplifiers daisy-chain, exactly as the R70 does. Pins 1,2,3,6,7,8 are unused by dbCAN and are flagged no-connect. Bus i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
Split termination: 2x62R with C207 to CAN_GND = 120R differential plus a common-mode path. SW201 is 2-pole so BOTH legs break — an SPST would leave an asymmetric 62R+C stub on CANL when open. The R70 uses a plain switched 120R; this is deliberately better for EMC. R201 sets ADM3053 slope control: f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
Rev B pads, isolated side (CAN_GND domain, DNP): J203 = the bus, in parallel with J201/J202, for a panel connector or terminal block. J204 = SW201 in parallel: a remote 2-pole switch wires TERM_A-TERM_MID and TERM_B-TERM_MID. Leave SW201 OFF when it is used.

Parts:
C501, C502, C503, C504: 100nF; C_0402_1005Metric; MPN CL05B104KO5NNNC; LCSC C1525
F501: PTC 0.35A; Fuse_1206_3216Metric; MPN BSMD1206-035-16V; LCSC C910827
F502: PTC 0.2A; Fuse_1206_3216Metric; MPN BSMD1206-020-30V; LCSC C883118
H501, H502, H503, H504: M3; MountingHole_3.2mm_M3
J501: FRONT PANEL; IDC-Header_2x08_P2.54mm_Vertical_SMD; MPN BH254VS-16P; LCSC C19190396
J502: USB DATA; PinHeader_1x03_P2.54mm_Vertical
JP501: FP_RESET; SolderJumper-2_P1.3mm_Bridged_RoundedPad1.0x1.5mm
R501, R502, R506, R507, R510, R511: 100R; R_0402_1005Metric; MPN 0402WGF1000TCE; LCSC C25076
R503, R504, R505: 10k; R_0402_1005Metric; MPN 0402WGF1002TCE; LCSC C25744
R508, R509: 4.7k; R_0402_1005Metric; MPN 0402WGF4701TCE; LCSC C25900
U501, U502, U503, U504: 74LVC1G06; SOT-353_SC-70-5; MPN SN74LVC1G06DCKR; LCSC C7828
U505, U506: ESDA6V1-5SC6; SOT-23-6; MPN ESDA6V1-5SC6Y; LCSC C2970918

Connections:
/Expansion — front-panel header, port pads, mounting/FP_3V3: F502.2, J501.2
/Expansion — front-panel header, port pads, mounting/FP_5V: F501.2, J501.1
/Expansion — front-panel header, port pads, mounting/FP_BOOT_N: J501.10, R502.2, U506.1 (IO1)
/Expansion — front-panel header, port pads, mounting/FP_CAN_N: J501.7, U503.4, U506.5 (IO4)
/Expansion — front-panel header, port pads, mounting/FP_ERR_N: J501.8, U504.4, U506.6 (IO5)
/Expansion — front-panel header, port pads, mounting/FP_FN1: J501.15, R506.2, U505.4 (IO3)
/Expansion — front-panel header, port pads, mounting/FP_FN2: J501.16, R507.2, U505.5 (IO4)
/Expansion — front-panel header, port pads, mounting/FP_LAN_N: J501.6, U502.4, U506.4 (IO3)
/Expansion — front-panel header, port pads, mounting/FP_ON_N: J501.5, U501.4, U506.3 (IO2)
/Expansion — front-panel header, port pads, mounting/FP_RESET_N: J501.9, JP501.2 (B), U505.1 (IO1)
/Expansion — front-panel header, port pads, mounting/FP_RST_R: JP501.1 (A), R501.2
/Expansion — front-panel header, port pads, mounting/FP_SCL: J501.14, R511.2, U505.3 (IO2)
/Expansion — front-panel header, port pads, mounting/FP_SDA: J501.13, R510.2, U505.6 (IO5)
BOOT: R502.1, R503.2; also elsewhere on the board
EN: R501.1; also elsewhere on the board
FN1: R504.2, R506.1; also elsewhere on the board
FN2: R505.2, R507.1; also elsewhere on the board
GND: C501.2, C502.2, C503.2, C504.2, J501.3, J501.4, J501.11, J501.12, J502.3, U501.3 (GND), U502.3 (GND), U503.3 (GND), U504.3 (GND), U505.2 (GND), U506.2 (GND); also elsewhere on the board
I2C_SCL: R509.2, R511.1; also elsewhere on the board
I2C_SDA: R508.2, R510.1; also elsewhere on the board
LED_CAN: U503.2; also elsewhere on the board
LED_ERR: U504.2; also elsewhere on the board
LED_LAN: U502.2; also elsewhere on the board
USB_DM: J502.1; also elsewhere on the board
USB_DP: J502.2; also elsewhere on the board
VCC_3V3: C501.1, C502.1, C503.1, C504.1, F502.1, R503.1, R504.1, R505.1, R508.1, R509.1, U501.2, U501.5 (VCC), U502.5 (VCC), U503.5 (VCC), U504.5 (VCC); also elsewhere on the board
VCC_5V: F501.1; also elsewhere on the board

Notes on the sheet:
J501 FRONT PANEL: 2x8 keyed IDC, ribbon to hardware/frontpanel 1 FP_5V (F501 0.35A) 2 FP_3V3 (F502 0.2A) 3 GND 4 GND 5 FP_ON_N 6 FP_LAN_N 7 FP_CAN_N 8 FP_ERR_N 9 FP_RESET_N (EN) 10 FP_BOOT_N (IO0) 11 GND 12 GND 13 FP_SDA (IO1) 14 FP_SCL (IO2) 15 FP_FN1 (IO38) 16 FP_FN2 (IO39) LED lines are open-dra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

Board: 4 copper layers, 100.0 x 81.0 mm, 129 parts (0 on the bottom side), 93 nets.

File hardware/rev-b/fab/generic/canary-revb-bom.csv:

Item,Qty,References,Value,Footprint,Manufacturer,MPN,LCSC,DNP,Notes
1,19,"C105,C108,C201,C203,C204,C206,C302-C304,C404-C407,C409,C419,C501-C504",100nF (BST) / 100nF / 100nF (VBG),C_0402_1005Metric,Samsung Electro-Mechanics,CL05B104KO5NNNC,C1525,,
2,2,"C106,C301",22uF 16V / 22uF,C_0805_2012Metric,Samsung Electro-Mechanics,CL21A226MAQNNNE,C45783,,
3,4,"C107,C202,C205,C403",10uF 16V / 10uF,C_0805_2012Metric,Samsung Electro-Mechanics,CL21A106KAYNNNE,C15850,,
4,4,C109-C112,1uF,C_0402_1005Metric,Samsung Electro-Mechanics,CL05A105KA5NQNC,C52923,,
5,1,C207,4.7nF,C_0603_1608Metric,FH (Guangdong Fenghua Advanced Tech),0603B472K500NT,C53987,,
6,2,"C401,C402",18pF,C_0402_1005Metric,FH (Guangdong Fenghua Advanced Tech),0402CG180J500NT,C1549,,
7,2,"C408,C410",4.7uF (1V2O) / 4.7uF (TOCAP),C_0603_1608Metric,Samsung Electro-Mechanics,CL10A475KO8NNNC,C19666,,
8,1,C411,1nF 2kV,C_1206_3216Metric,FH (Guangdong Fenghua Advanced Tech),1206B102K202NT,C9196,,
9,1,C412,10nF (TCT),C_0402_1005Metric,Samsung Electro-Mechanics,CL05B103KB5NNNC,C15195,,
10,1,C413,6.8nF (RCT),C_0402_1005Metric,YAGEO,CC0402KRX7R9BB682,C93654,,
11,4,C414-C417,10nF 100V,C_0402_1005Metric,YAGEO,CC0402KRX7R0BB103,C527014,,
12,1,C418,47uF,C_1206_3216Metric,Samsung,CL31A476MPHNNNE,C96123,,
13,1,D105,SMF5.0A,D_SOD-123F,MDD,SMF5.0A,C193402,,
14,1,D201,NUP2105L,SOT-23,TECH PUBLIC,NUP2105LT1G,C2890118,,
15,3,"D301,D303,D304",LAN (green) / CAN (green) / ON (green),LED_0603_1608Metric,Hubei KENTO Elec,KT-0603G,C12624,,
16,1,D302,ERR (red),LED_0603_1608Metric,Hubei KENTO Elec,KT-0603R,C2286,,
17,2,"D401,D402",MB10S,TO-269AA,MDD,MB10S-50MIL,C2488,,
18,1,D403,SMAJ58A,D_SMA,MDD,SMAJ58A,C123816,,
19,2,"F101,F102",PTC 1.1A,Fuse_1206_3216Metric,BHFUSE,BSMD1206-110-30V,C21714343,,
20,1,F501,PTC 0.35A,Fuse_1206_3216Metric,BHFUSE,BSMD1206-035-16V,C910827,,
21,1,F502,PTC 0.2A,Fuse_1206_3216Metric,BHFUSE,BSMD1206-020-30V,C883118,,
22,1,FB201,600R@100MHz,L_0603_1608Metric,Murata Electronics,BLM18AG601SN1D,C19330,,
23,1,J102,USB-C 16P,USB_C_Receptacle_HRO_TYPE-C-31-M-12,Korean Hroparts Elec,TYPE-C-31-M-12,C165948,,
24,1,J201,etherCON NE8FBH CAN A,Neutrik_etherCON_NE8FBH,,,,,no LCSC part: hand-fit or customer-supplied
25,1,J202,etherCON NE8FBH CAN B,Neutrik_etherCON_NE8FBH,,,,,no LCSC part: hand-fit or customer-supplied
26,1,J301,UART/debug 1.27mm,PinHeader_1x06_P1.27mm_Vertical,,,,,no LCSC part: hand-fit or customer-supplied
27,1,J401,etherCON NE8FBH LAN,Neutrik_etherCON_NE8FBH,,,,,no LCSC part: hand-fit or customer-supplied
28,1,J501,FRONT PANEL,IDC-Header_2x08_P2.54mm_Vertical_SMD,XFCN,BH254VS-16P,C19190396,,
29,1,L102,2.2uH 2A,L_Bourns-SRN4018,BOURNS,SRN4018-2R2M,C913207,,
30,1,R103,31.6k 1%,R_0402_1005Metric,UNI-ROYAL(Uniroyal Elec),0402WGF3162TCE,C11463,,
31,7,"R104,R107,R301,R413,R503-R505",10k 1% / 10k,R_0402_1005Metric,UNI-ROYAL(Uniroyal Elec),0402WGF1002TCE,C25744,,
32,5,"R106,R302-R305",1k,R_0402_1005Metric,UNI-ROYAL(Uniroyal Elec),0402WGF1001TCE,C11702,,
33,1,R108,100k,R_0402_1005Metric,UNI-ROYAL,0402WGF1003TCE,C25741,,
34,1,R109,33k,R_0402_1005Metric,UNI-ROYAL,0402WGF3302TCE,C25779,,
35,2,"R201,R412",0R / 0R (XO series),R_0402_1005Metric,UNI-ROYAL(Uniroyal Elec),0402WGF0000TCE,C17168,,
36,2,"R202,R203",62R,R_0603_1608Metric,UNI-ROYAL(Uniroyal Elec),0603WAF620JT5E,C23222,,
37,1,R401,12.4k 1%,R_0402_1005Metric,UNI-ROYAL(Uniroyal Elec),0402WGF1242TCE,C11692,,
38,4,R402-R405,75R,R_0603_1608Metric,UNI-ROYAL(Uniroyal Elec),0603WAF750JT5E,C4275,,
39,4,R406-R409,49.9R 1%,R_0402_1005Metric,UNI-ROYAL(Uniroyal Elec),0402WGF499JTCE,C25120,,
40,1,R410,10R 1%,R_0402_1005Metric,UNI-ROYAL(Uniroyal Elec),0402WGF100JTCE,C25077,,
41,1,R411,1M,R_0402_1005Metric,UNI-ROYAL(Uniroyal Elec),0402WGF1004TCE,C26083,,
42,6,"R501,R502,R506,R507,R510,R511",100R,R_0402_1005Metric,UNI-ROYAL,0402WGF1000TCE,C25076,,
43,2,"R508,R509",4.7k,R_0402_1005Metric,UNI-ROYAL,0402WGF4701TCE,C25900,,
44,1,SW201,TERMINATE 120R,SW_DIP_SPSTx02_Slide_9.78x7.26mm_W7.62mm_P2.54mm,,,,,no LCSC part: hand-fit or customer-supplied
45,2,"SW301,SW302",RESET / BOOT,SW_SPST_PTS645Sx43SMTR92,C&K,PTS645SK43SMTR92LFS,C221871,,
46,1,T401,B1608S,Transformer_Ethernet_Bourns_PT61017PEL,CND-tek,B1608S,C507596,,
47,1,U103,AP63200WU,TSOT-23-6,Diodes Incorporated,AP63200WU-7,C2071868,,
48,1,U104,CH224K,SSOP-10-1EP_3.9x4.9mm_P1mm_EP2.1x3.3mm,WCH(Jiangsu Qin Heng),CH224K,C970725,,
49,1,U105,TPS2116,SOT-583-8,Texas Instruments,TPS2116DRLR,C3235557,,
50,1,U106,LM66100,SOT-363_SC-70-6,Texas Instruments,LM66100DCKR,C2869734,,
51,1,U201,ADM3053BRWZ,SOIC-20W_7.5x12.8mm_P1.27mm,Analog Devices,ADM3053BRWZ-REEL7,C117821,,
52,1,U301,ESP32-S3-WROOM-1-N8R2,ESP32-S3-WROOM-1,Espressif Systems,ESP32-S3-WROOM-1-N8R2,C2913204,,
53,1,U401,W5500,LQFP-48_7x7mm_P0.5mm,WIZNET,W5500,C32843,,
54,1,U402,DP9900M-5V,SDAPO_DP9900M,SDAPO,DP9900M-5V,C5380106,,
55,4,U501-U504,74LVC1G06,SOT-353_SC-70-5,Texas Instruments,SN74LVC1G06DCKR,C7828,,
56,2,"U505,U506",ESDA6V1-5SC6,SOT-23-6,STMicroelectronics,ESDA6V1-5SC6Y,C2970918,,
57,1,Y401,25MHz 10ppm,Crystal_SMD_3225-4Pin_3.2x2.5mm,YXC Crystal Oscillators,X322525MOB4SI,C9006,,
58,1,J103,5V AUX IN,PinHeader_1x02_P2.54mm_Vertical,,,,DNP,
59,1,J203,CAN BUS,PinHeader_1x03_P2.54mm_Vertical,,,,DNP,
60,1,J204,TERM REMOTE,PinHeader_1x03_P2.54mm_Vertical,,,,DNP,
61,1,J502,USB DATA,PinHeader_1x03_P2.54mm_Vertical,,,,DNP,

## Code that names these connections

File hardware/scripts/probe_points.py (part):

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          "3.3 - 5.1 V",
          "0 V = R106 open or U104 shorted; the exact value depends on CH224K Iq, which we have not measured",
          "PWR", "predicted", (1, -1)),
    Probe("P6", "U104.10", "PD_PG", "CH224K power-good to GPIO18", "DMM-V",
          "logic level, stable; note which level a good board shows",
          "the polarity is unverified - record it on board #1 and make that the limit",
          "PWR", "predicted", (1, 1)),
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          "3.23 - 3.43 V",
          "the header is the fallback console when USB will not enumerate",
          "MCU", "derived", (1, -1)),
    Probe("M3", "J301.3", "UART0_TXD", "debug header pin 3, board -> host", "SCOPE",
          "idle high 3.3 V, 115200 baud bursts at reset",
          "silent at reset = the S3 is not running its ROM bootloader",
          "MCU", "derived", (1, 1)),
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          "3.23 - 3.43 V, and D304 lit",
          "rail present but D304 dark = LED fitted backwards or R305 open",
          "MCU", "derived", (-1, 1)),
    Probe("M6", "R302.1", "LED_LAN", "D301 drive from GPIO15", "DMM-V",
          "ACTIVE HIGH: ~3.3 V when lit, ~0 V when dark",
          "see the polarity note in BENCH-BRINGUP.md - the schematic is active high",
          "MCU", "derived", (-1, -1)),
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          "0x04 in the 4th byte of that transaction",
          "0x00 or 0xFF = W5500 not answering: supply, crystal or reset",
          "ETH", "spec", (2.6, -1.0)),
    Probe("E10", "U401.37", "ETH_RSTn", "W5500 reset, from GPIO9", "DMM-V",
          "3.23 - 3.43 V once firmware has run",
          "low = held in reset, and every SPI read returns 0x00",
          "ETH", "derived", (-1, -1)),
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          "under 0.3 V to CAN_GND - R201 is 0R, so high-speed mode",
          "volts here = R201 missing, and the transceiver drops to standby",
          "CAN", "spec", (1, -1)),
    Probe("K5", "J201.4", "CANH", "bus high, at CAN jack A (pin 4)", "DMM-V",
          "idle 2.3 - 2.7 V to CAN_GND; K5-K6 reads 118-130 ohm with SW201 IN, "
          "over 10 kohm with it OUT",
          "0 V or 5 V = the transceiver is stuck dominant, which jams the whole bus",
          "CAN", "spec", (-1, -1)),
    Probe("K6", "J201.5", "CANL", "bus low, at CAN jack A (pin 5)", "DMM-V",
          "idle 2.3 - 2.7 V to CAN_GND, within 100 mV of K5",
          "the K5-K6 resistance also tells a CAN jack from the LAN jack when the "
          "silkscreen is unreadable: only J201/J202 show 124 ohm",
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