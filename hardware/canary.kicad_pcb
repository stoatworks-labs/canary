# Repository stoatworks-labs/canary

File README.md:

# CANary

> **AI-assisted project.** This codebase was created with [Claude](https://claude.com/claude-code)
> (Anthropic), directed and reviewed by a human author.

An open-hardware **IP-to-CAN converter compatible with the d&b audiotechnik R70
Ethernet-to-CAN interface**. It speaks the R70's network protocol, so **R1** can
find it, connect to it and reach CAN-era d&b amplifiers (D6, D12, E-PAC) through
hardware you can build yourself.

**ESP32-S3 · W5500 Ethernet · ADM3053 isolated CAN · USB-C PD power · three
Neutrik etherCONs**, in a one-piece 3D-printed case.

> **Status: prototype.** Rev A boards have been built. Board #1 passes its
> self-test, takes a DHCP lease, and is discovered and listed by R1 over
> Ethernet. The host-side acceptance run passes 19/19 over Ethernet and over the
> USB network link. On 2026-10-28 it went on a real bus with two d&b amplifiers:
> both answered through the isolation barrier on both CAN jacks, and the control
> application connected through the board and drove mute and gain in both
> directions ([bring-up log §12](hardware/fab/test/BRINGUP-LOG-0001.md)).
> **Not yet done:** after a CAN cable pull the CAN side stayed deaf until the
> board was reset. A fix exists in development firmware, but it is not yet in
> this repository or any release, and has not been re-run on a board. LAN pulls,
> amplifier power cycles and long runs are untested, and only one board has been
> tried. Treat it as a development platform, not show equipment.

## What is in this repo

| Path | What |
|---|---|
| [`hardware/`](hardware/) | Rev A board: KiCad 10 project (4 sheets, 100 × 81 mm, 4 layers), symbol/footprint library, fab outputs (Gerbers, BOM, pick-and-place, interactive BOM) and the design scripts that placed and routed it |
| [`hardware/fab/test/`](hardware/fab/test/) | Bench bring-up procedure, functional test spec, probe points, and the bring-up log of board #1 |
| [`hardware/enclosure/`](hardware/enclosure/) | The one-piece **tube** case: parametric generator (CadQuery), STEP and STL for the body, end plates, LED window insert and switch cover, ready-sliced Bambu Lab plates, and a jig for pressing the heat-set inserts |
| [`firmware/`](firmware/) | ESP-IDF 5.5 firmware: the Ethernet bridge, discovery responder, CAN at dbCAN's fixed 100 kbit/s, status LEDs, and an optional USB network device with an on-device settings page |
| [`tools/`](tools/) | Python reference implementation of the protocol, a host-side emulator you can point R1 at with no hardware, and the board acceptance test |
| [`docs/`](docs/) | Protocol reference, user guide, API, design decisions, fab notes |

## How it works

The R70 is a transparent bridge. It does not interpret d&b's amplifier
parameters, it carries CAN frames. Its Ethernet side speaks the **RM Byte
Command Protocol**, which RM Michaelides (now Proemion) publish. R1 finds
interfaces with a small UDP discovery exchange on port 33333, documented here
from captures of R1's discovery traffic and confirmed live. CANary implements
both, and nothing else. It has no knowledge of amplifier parameters and needs
none.

| | |
|---|---|
| Data socket | TCP **30000**, RM Byte Command Protocol |
| Discovery | UDP **33333** ([PROTOCOL.md §4](docs/PROTOCOL.md)) |
| CAN | dbCAN: CAN 2.0A, 11-bit IDs, **100 kbit/s fixed** |

Every claim in [docs/PROTOCOL.md](docs/PROTOCOL.md) is tagged `[spec]`,
`[derived]` or `[unknown]`, so you can tell what comes from a published
document and what is inferred.

## Getting started

**Flash a board from the browser.** The [CANary Flasher](https://canary-flasher.stoatworks-labs.com)
writes the current release over Web Serial (Chrome/Edge). Pick *Standard*
(Ethernet only), or *USB network + config page*, which also makes the unit a USB
network adapter at `192.168.7.1` with a settings page.

**Build the firmware yourself:**

```bash
. ~/esp/esp-idf/export.sh            # ESP-IDF v5.5
cd firmware
idf.py -B build -DSDKCONFIG=build/sdkconfig build
idf.py -B build -p /dev/cu.usbmodem* flash monitor
```

The USB network image is an overlay:
`-DSDKCONFIG_DEFAULTS="sdkconfig.defaults;sdkconfig.usb-ncm"` with its own `-B`
and `-DSDKCONFIG`. Without `-DSDKCONFIG` the overlay is silently ignored. See
[docs/DEVELOPING.md](docs/DEVELOPING.md).

**Try it against R1 with no hardware at all:**

```bash
python3 tools/r70_emu.py serve --answer-from <your LAN address>
```

In R1, go **Offline**, tick the interface's activation checkbox, and go back
**Online**. The checkbox is greyed out while Online.

**Build a board.** Fab outputs are in [`hardware/fab/`](hardware/fab/). Read
[`hardware/fab/test/BENCH-BRINGUP.md`](hardware/fab/test/BENCH-BRINGUP.md) §0
before powering one. The three etherCONs are physically identical and two of
them are CAN. Rev A has no PoE, and a passive PoE injector will destroy it.

**Print a case.** [`hardware/enclosure/`](hardware/enclosure/). The body prints
standing on its end in ABS-GF with no support (about 5 h and 131 g with both end plates,
on a 0.4 mm nozzle). The LED window inserts and switch covers are white PLA.

Full instructions: [docs/USER-GUIDE.md](docs/USER-GUIDE.md).

## Tests

```bash
python3 -m venv .venv && ./.venv/bin/pip install pytest
./run_tests.sh      # Python reference, C firmware components on the host, fuzzers
```

The firmware's protocol components are ESP-IDF-free, so they compile and run on
the host against the same test vectors as the Python reference. Those vectors
come from the vendor's worked examples and from real captures. When extending
the protocol, add vectors from a document or a capture: a test that encodes
your own assumption proves nothing.

## Roadmap

- [x] CAN on a real amplifier bus, and R1 driving amplifiers through the board —
      board #1, 2026-10-28 ([bring-up log §12](hardware/fab/test/BRINGUP-LOG-0001.md)),
      with one fault: the CAN side did not recover from a cable pull until reset
- [ ] Recovery after a CAN cable pull, on a board (fixed in development firmware, not yet
      here); amplifier power cycles, LAN pulls and long runs
- [ ] R1 discovering a unit over USB; Windows hosts for the USB network image
- [ ] Rev B: PoE, Ethernet ESD/TVS, silkscreen cleanup
- [ ] R60-compatible USB serial mode

Issues and pull requests are welcome, especially bench results from anyone with
a D6/D12/E-PAC rig.

## Licence

Board: **CERN-OHL-S-2.0** · Enclosure and docs: **CC BY-SA 4.0** · Firmware and
tools: **MIT**. See [LICENSE](LICENSE) for which applies to what, and for the
exceptions (fonts, the Stoatworks Labs mark).

## Disclaimer

CANary is an independent implementation, built from published documentation
and observed network traffic. It contains no d&b audiotechnik or RM Michaelides
code or firmware. Vendor manuals are not redistributed here; see
[docs/SOURCES.md](docs/SOURCES.md) for where to get them.

"d&b audiotechnik", "R1", "R70" and "dbCAN" are trademarks of d&b audiotechnik
GmbH & Co. KG, used only to describe compatibility. This project is not
affiliated with, endorsed by, or supported by d&b audiotechnik or Proemion.
Using it with d&b equipment is at your own risk, and may affect that
equipment's warranty or support status.

## KiCad design hardware/canary.kicad_pcb

File hardware/README.md (part):

# CANary hardware

KiCad 10 project for the R70-compatible IP-to-CAN bridge.
Architecture and the reasoning behind every part choice: [../docs/DECISIONS.md](../docs/DECISIONS.md) (H1–H19).

> ## ⚠ Written at the schematic stage
>
> This README is from before layout, and before PoE was dropped from rev A, so its status and
> the PoE parts of the Power and Ethernet sections are out of date. Where it disagrees with the
> board files, the board files win:
>
> | This README says | Rev A as built |
> |---|---|
> | PCB not started; nothing laid out, routed, DRC'd or fabricated | routed with DRC 0 errors and 0 unconnected, and built turnkey from `d9a725d` ([`../docs/FAB.md`](../docs/FAB.md)) |
> | PoE + USB-C, OR'd by Schottky; U101 still to place | USB-C PD only. PoE is deferred to rev B (DECISIONS.md H19), U101 isn't fitted and the OR-ing diodes are gone (H19a) |
> | etherCON footprint is a placeholder | `canary:Neutrik_etherCON_NE8FBH` on J201, J202 and J401 |
> | `POE_MODEA_*` / `POE_MODEB_*` nets | `ETH_CT_TD` / `ETH_CT_RD` / `ETH_SPARE_1/2` (H19c) |
>
> For the board as built, see [`../docs/FAB.md`](../docs/FAB.md) and
> [`fab/test/BRINGUP-LOG-0001.md`](fab/test/BRINGUP-LOG-0001.md).

## Status

| Sheet | File | State |
|---|---|---|
| Root | `canary.kicad_sch` | 4 sheets placed, CAN sheet pins linked |
| Power — PoE + USB-C, 5 V / 3V3 | `power.kicad_sch` | **drawn**, 15 symbols, 0 unconnected pins (U101 pending, see below) |
| MCU — ESP32-S3-WROOM-1, USB, LEDs | `mcu.kicad_sch` | **drawn**, 17 symbols, 0 unconnected pins |
| Ethernet — W5500 SPI, PoE tap, etherCON | `ethernet.kicad_sch` | **drawn**, 18 symbols, 0 unconnected pins |
| dbCAN — ADM3053 isolated | `can.kicad_sch` | **drawn**, 16 symbols, 0 unconnected pins |
| PCB | `canary.kicad_pcb` | **not started** |

**All four sheets are drawn** — 68 symbols, 0 unconnected pins on every sheet, and
the exported netlist confirms every cross-sheet bus connects. One part is still
missing (U101, see below).

**All 68 symbols have footprints assigned** — except that the three etherCON jacks
carry a deliberate placeholder (see below).

Nothing has been laid out, routed, DRC'd or fabricated.

> ### ⚠ etherCON footprint is a placeholder
> J201/J202/J401 use `Connector_RJ:RJ45_OST_PJ012-8P8CX_Vertical` so the netlist
> imports and layout can begin. **It is not an NE8FBH and must be replaced before
> fab.** KiCad ships no Neutrik etherCON footprint; it has to be drawn from the
> NE8FBH datasheet.
>
> Also note the variant correction: **NE8FDP cannot be used.** It is a panel-mount
> *feedthrough* whose rear is a female RJ45 socket — it does not solder to a PCB,
> and would need an internal patch lead per connector. NE8FBH is the horizontal
> PCB-mount part. See DECISIONS.md H6a.

## Architecture pivot (2026-07-23) — read this first

The MCU changed from **classic ESP32 + LAN8720 RMII** to **ESP32-S3 + W5500 SPI**,
and the barrel jack is gone. Full reasoning in `../docs/DECISIONS.md` H14–H18.

The trigger: the classic ESP32 has **no native USB peripheral**. It is UART-only,
so it physically cannot present as a USB network adapter or emulate an R60 — both
of which the S3 makes possible, while also deleting the USB-UART programming
bridge. The S3 has no EMAC, so RMII gives way to W5500-over-SPI; at dbCAN's
100 kbit/s that is ample, and it removes the 50 MHz oscillator and the
length-matched RMII group, previously the most EMC-critical things on the board.

Verified before committing to it, not assumed: `esp_eth_mac_w5500.c` ships in the
installed ESP-IDF v5.5.5, `tusb_ncm` is an official example listing ESP32-S3 as
supported, and the S3's `soc_caps.h` confirms TWAI and USB-OTG.

## ERC

**6 errors, all the same expected cause:** `power_pin_not_driven` on the rails,
because U101 is not placed and there are no `PWR_FLAG`/power symbols yet.

**Deliberately not silenced with PWR_FLAG.** Those flags would equally hide a
genuinely undriven rail. They should clear once U101 lands and the rails are
driven; if they don't, that is a real finding rather than a formality.

Warnings that remain are cosmetic: `same_local_global_label` where a local label
on a component pin shares a name with a global rail (connectivity is correct —
KiCad merges them), and `isolated_pin_label` on nets whose other end lives on the
still-empty Ethernet sheet (`SPI_*`, `ETH_*`, `POE_*`).

### A trap worth knowing

Deleting a component does **not** delete the net labels `batch_connect_to_net`
placed at its pins. Those orphans linger and ERC surfaces them one at a time, so
it looks like whack-a-mole. Worse, one of them was a genuine short: a leftover
`V5_DC` label from the deleted wide-Vin buck ended up co-located with `VBUS` on
the new USB OR diode, and ERC reported `multiple_net_names` — USB VBUS would have
been silently renamed to the old buck's output net. **After deleting parts, sweep
their pin coordinates for orphaned labels rather than trusting the delete.**

## What the Power sheet encodes

Two sources, OR'd by Schottky into `VCC_5V` — **no barrel jack**:

- **PoE** → Ag97005-FL (U101) → `POE_5V` → D104 → `VCC_5V`
- **USB-C** → `VBUS` → F101 (PTC) → D103 → `VCC_5V`

Both give 5 V directly, so there is no wide-Vin buck and no intermediate rail —
that whole chain (12 parts) was deleted in the pivot. `VCC_5V` feeds the ADM3053
and U103, the only remaining converter (5 V → 3V3).

**USB-PD is real**, not a passive sink: U104 is a **CH224K** negotiating over
CC1/CC2. It happens to be in KiCad's stock `Interface_USB` library, so no custom
symbol and no library-cache blocker.

> ### ⚠ CFG1 is safety-critical
> The CH224K picks its requested voltage from the CFG1/2/3 levels, and the
> datasheet warns it requests **20 V if CFG1 floats at power-up**. This board
> cannot survive that — 20 V would pass D103 straight onto `VCC_5V` and destroy
> the ADM3053 (VCC abs max ~6 V) and U103's input.
>
> CFG1 is therefore **hard-tied to `PD_VDD` in copper, not driven by an MCU GPIO**.
> It could not be a GPIO even in principle: the MCU is powered *from* this rail,
> so it cannot configure the PD chip before the rail it depends on exists.

The 5.1 k Rd pulldowns were removed — the CH224K drives CC itself, and fixed
resistors in parallel would present the wrong impedance and break PD signalling.
CH224K DP/DM are deliberately unconnected: they serve legacy BC1.2/QC, and wiring
them to the data pair would corrupt the USB link needed for NCM/R60/programming.

We request **5 V**, not a higher PD voltage, because 5 V feeds the ADM3053
directly — asking for 9 V or 12 V would reintroduce the wide-Vin buck H17 deleted.

Both bucks use the **adjustable** AP63200WU rather than the fixed AP63205/AP63203
variants: those are `extends` aliases that Konnect resolves to zero pins.

## What the Ethernet sheet encodes

**etherCON has no magnetics.** A Neutrik etherCON is a rugged *shell* around a
plain RJ45, so unlike the usual "HR911105A magjack" design the transformer must be
a separate part — T401 (PT61017PEL, 10/100 with centre taps). Chain: J401 →
T401 line side → T401 PHY side → W5500.

PoE is tapped here and powered on the Power sheet: **Mode A** from the T401 centre
taps, **Mode B** from J401 pins 4/5 and 7/8. All four go to U101's VINA–VIND,
whose internal bridge rectifiers make them polarity-insensitive — which is why
there is no external diode bridge and why both modes work without a jumper.

> ⚠ `POE_MODEA_*` and `POE_MODEB_*` sit at **up to 57 V** relative to GND. They are
> not logic nets. This is a **second** isolation concern, separate from the
> ADM3053 barrier on the dbCAN sheet, and it has its own project design rule.

`CHASSIS` is deliberately a separate net from `GND` (etherCON shell, USB-C shell,
Bob Smith termination, mounting hardware). **Choose the single GND↔CHASSIS bond
point at layout, and make it exactly one point.**

The W5500's four LED outputs are deliberately unused: the front-panel LAN LED is

Parts:
C105: 100nF (BST); C_0402_1005Metric
C106: 22uF 16V; C_0805_2012Metric
C107: 10uF 16V; C_0805_2012Metric
C108: 100nF; C_0402_1005Metric
C109: 1uF; C_0402_1005Metric
F101: PTC 1.1A; Fuse_1206_3216Metric
J102: USB-C 16P; USB_C_Receptacle_HRO_TYPE-C-31-M-12
L102: 2.2uH 2A; L_Bourns-SRN4018
R103: 31.6k 1%; R_0402_1005Metric
R104: 10k 1%; R_0402_1005Metric
R106: 1k; R_0402_1005Metric
R107: 10k; R_0402_1005Metric
U103: AP63200WU; TSOT-23-6
U104: CH224K; SSOP-10-1EP_3.9x4.9mm_P1mm_EP2.1x3.3mm

Connections:
/Power — PoE + USB-C PD, 5V and 3V3/BST2: C105.2, U103.6 (BST)
/Power — PoE + USB-C PD, 5V and 3V3/FB2: R103.2, R104.1, U103.1 (FB)
/Power — PoE + USB-C PD, 5V and 3V3/PD_VBUS_SENSE: R107.2, U104.8 (VBUS)
/Power — PoE + USB-C PD, 5V and 3V3/PD_VDD: C109.1, R106.2, U104.1 (VDD), U104.9 (CFG1)
/Power — PoE + USB-C PD, 5V and 3V3/SW2: C105.1, L102.1, U103.5 (SW)
/Power — PoE + USB-C PD, 5V and 3V3/USB_CC1: J102.A5 (CC1), U104.7 (CC1)
/Power — PoE + USB-C PD, 5V and 3V3/USB_CC2: J102.B5 (CC2), U104.6 (CC2)
/Power — PoE + USB-C PD, 5V and 3V3/VBUS_RAW: F101.1, J102.A4 (VBUS), J102.A9 (VBUS), J102.B4 (VBUS), J102.B9 (VBUS)
CHASSIS: J102.SH (SHIELD); also elsewhere on the board
GND: C106.2, C107.2, C108.2, C109.2, J102.A1 (GND), J102.A12 (GND), J102.B1 (GND), J102.B12 (GND), R104.2, U103.4 (GND), U104.11 (GND); also elsewhere on the board
PD_PG: U104.10 (PG); also elsewhere on the board
USB_DM: J102.A7 (D-), J102.B7 (D-); also elsewhere on the board
USB_DP: J102.A6 (D+), J102.B6 (D+); also elsewhere on the board
VCC_3V3: C106.1, L102.2, R103.1; also elsewhere on the board
VCC_5V: C107.1, C108.1, F101.2, R106.1, R107.1, U103.2 (EN), U103.3 (IN); also elsewhere on the board

Notes on the sheet:
ONE POWER SOURCE IN REV A: USB-C PD ONLY — no barrel jack, no PoE. USB-C: VBUS -> F101 (PTC) -> VCC_5V — direct, no OR-ing diode. PD negotiates 5V at the connector, so there is no wide-Vin buck and no intermediate rail. VCC_5V feeds the ADM3053 and U103 (5V -> 3V3 for the S3, W5500 and ADM3053 VIO)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
POE IS DEFERRED TO REV B — BY DECISION (H19, 2026-07-25), NOT BY A TOOLING FAULT. Rev A is USB-C PD only. The Ag97005-FL module was this board's risk concentration: 56 x 14 mm on a board meant to be as small as practical, NOT on LCSC so JLCPCB cannot assemble it, hand-soldered, and its land pattern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

Parts:
C301: 22uF; C_0805_2012Metric
C302, C303, C304: 100nF; C_0402_1005Metric
D301: LAN (green); LED_0603_1608Metric
D302: ERR (red); LED_0603_1608Metric
D303: CAN (green); LED_0603_1608Metric
D304: ON (green); LED_0603_1608Metric
J301: UART/debug 1.27mm; PinHeader_1x06_P1.27mm_Vertical
R301: 10k; R_0402_1005Metric
R302, R303, R304, R305: 1k; R_0402_1005Metric
SW301: RESET; SW_SPST_PTS645Sx43SMTR92
SW302: BOOT; SW_SPST_PTS645Sx43SMTR92
U301: ESP32-S3-WROOM-1-N8; ESP32-S3-WROOM-1

Connections:
/MCU — ESP32-S3-WROOM-1, USB, LEDs/BOOT: J301.5, SW302.1, U301.27 (IO0)
/MCU — ESP32-S3-WROOM-1, USB, LEDs/EN: C304.1, J301.6, R301.2, SW301.1, U301.3 (EN)
/MCU — ESP32-S3-WROOM-1, USB, LEDs/LED_CAN: R304.1, U301.10 (IO17)
/MCU — ESP32-S3-WROOM-1, USB, LEDs/LED_CAN_K: D303.2 (A), R304.2
/MCU — ESP32-S3-WROOM-1, USB, LEDs/LED_ERR: R303.1, U301.9 (IO16)
/MCU — ESP32-S3-WROOM-1, USB, LEDs/LED_ERR_K: D302.2 (A), R303.2
/MCU — ESP32-S3-WROOM-1, USB, LEDs/LED_LAN: R302.1, U301.8 (IO15)
/MCU — ESP32-S3-WROOM-1, USB, LEDs/LED_LAN_K: D301.2 (A), R302.2
/MCU — ESP32-S3-WROOM-1, USB, LEDs/LED_ON_K: D304.2 (A), R305.2
/MCU — ESP32-S3-WROOM-1, USB, LEDs/UART0_RXD: J301.4, U301.36 (RXD0)
/MCU — ESP32-S3-WROOM-1, USB, LEDs/UART0_TXD: J301.3, U301.37 (TXD0)
CAN_RX: U301.5 (IO5); also elsewhere on the board
CAN_TX: U301.4 (IO4); also elsewhere on the board
ETH_CSn: U301.18 (IO10); also elsewhere on the board
ETH_INTn: U301.22 (IO14); also elsewhere on the board
ETH_RSTn: U301.17 (IO9); also elsewhere on the board
GND: C301.2, C302.2, C303.2, C304.2, D301.1 (K), D302.1 (K), D303.1 (K), D304.1 (K), J301.2, SW301.2, SW302.2, U301.1 (GND), U301.40 (GND), U301.41 (GND); also elsewhere on the board
PD_PG: U301.11 (IO18); also elsewhere on the board
SPI_MISO: U301.21 (IO13); also elsewhere on the board
SPI_MOSI: U301.19 (IO11); also elsewhere on the board
SPI_SCK: U301.20 (IO12); also elsewhere on the board
USB_DM: U301.13 (USB_D-); also elsewhere on the board
USB_DP: U301.14 (USB_D+); also elsewhere on the board
VCC_3V3: C301.1, C302.1, C303.1, J301.1, R301.1, R305.1, U301.2 (3V3); also elsewhere on the board

Notes on the sheet:
ESP32-S3-WROOM-1 PIN MAP — keep firmware (components/dbcan, net, bridge) in step. USB D+ = IO20, D- = IO19 FIXED IN SILICON, not reassignable. The symbol names them USB_D+/USB_D-. TWAI/CAN CAN_TX = IO4, CAN_RX = IO5 -> ADM3053 on the dbCAN sheet W5500 SCK=IO12 MOSI=IO11 MISO=IO13 CSn=IO10 INTn=IO14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

Parts:
C401, C402: 18pF; C_0402_1005Metric
C403: 10uF; C_0805_2012Metric
C404, C405, C406, C407: 100nF; C_0402_1005Metric
C408: 4.7uF (1V2O); C_0603_1608Metric
C409: 100nF (VBG); C_0402_1005Metric
C410: 4.7uF (TOCAP); C_0603_1608Metric
C411: 1nF 2kV; C_1206_3216Metric
C412: 10nF (TCT); C_0402_1005Metric
C413: 6.8nF (RCT); C_0402_1005Metric
J401: etherCON NE8FBH LAN; Neutrik_etherCON_NE8FBH
R401: 12.4k 1%; R_0402_1005Metric
R402, R403, R404, R405: 75R; R_0603_1608Metric
R406, R407, R408, R409: 49.9R 1%; R_0402_1005Metric
R410: 10R 1%; R_0402_1005Metric
R411: 1M; R_0402_1005Metric
R412: 0R (XO series); R_0402_1005Metric
T401: PT61017PEL; Transformer_Ethernet_Bourns_PT61017PEL
U401: W5500; LQFP-48_7x7mm_P0.5mm
Y401: 25MHz 10ppm; Crystal_SMD_3225-4Pin_3.2x2.5mm

Connections:
/Ethernet — W5500 SPI, PoE magjack, etherCON/BOB_SMITH: C411.1, R402.2, R403.2, R404.2, R405.2
/Ethernet — W5500 SPI, PoE magjack, etherCON/ETH_1V2: C408.1, U401.22 (1V2O)
/Ethernet — W5500 SPI, PoE magjack, etherCON/ETH_CT_RD: R403.1, T401.7 (C_RD)
/Ethernet — W5500 SPI, PoE magjack, etherCON/ETH_CT_TD: R402.1, T401.2 (C_TD)
/Ethernet — W5500 SPI, PoE magjack, etherCON/ETH_EXRES: R401.1, U401.10 (EXRES1)
/Ethernet — W5500 SPI, PoE magjack, etherCON/ETH_RCT: C413.1, R408.2, R409.2, T401.10 (C_RX)
/Ethernet — W5500 SPI, PoE magjack, etherCON/ETH_RXN: R409.1, T401.9 (RX-), U401.5 (RXN)
/Ethernet — W5500 SPI, PoE magjack, etherCON/ETH_RXP: R408.1, T401.11 (RX+), U401.6 (RXP)
/Ethernet — W5500 SPI, PoE magjack, etherCON/ETH_SPARE_1: J401.4, J401.5, R404.1
/Ethernet — W5500 SPI, PoE magjack, etherCON/ETH_SPARE_2: J401.7, J401.8, R405.1
/Ethernet — W5500 SPI, PoE magjack, etherCON/ETH_TCT: C412.1, R406.2, R407.2, R410.2, T401.15 (C_TX)
/Ethernet — W5500 SPI, PoE magjack, etherCON/ETH_TOCAP: C410.1, U401.20 (TOCAP)
/Ethernet — W5500 SPI, PoE magjack, etherCON/ETH_TXN: R407.1, T401.14 (TX-), U401.1 (TXN)
/Ethernet — W5500 SPI, PoE magjack, etherCON/ETH_TXP: R406.1, T401.16 (TX+), U401.2 (TXP)
/Ethernet — W5500 SPI, PoE magjack, etherCON/ETH_VBG: C409.1, U401.18 (VBG)
/Ethernet — W5500 SPI, PoE magjack, etherCON/ETH_XI: C401.1, R411.1, U401.30 (XI/CLKIN), Y401.1
/Ethernet — W5500 SPI, PoE magjack, etherCON/ETH_XO: C402.1, R411.2, R412.2, Y401.2
/Ethernet — W5500 SPI, PoE magjack, etherCON/ETH_XO_DRV: R412.1, U401.31 (XO)
/Ethernet — W5500 SPI, PoE magjack, etherCON/LAN_RD_N: J401.6, T401.8 (RD-)
/Ethernet — W5500 SPI, PoE magjack, etherCON/LAN_RD_P: J401.3, T401.6 (RD+)
/Ethernet — W5500 SPI, PoE magjack, etherCON/LAN_TD_N: J401.2, T401.3 (TD-)
/Ethernet — W5500 SPI, PoE magjack, etherCON/LAN_TD_P: J401.1, T401.1 (TD+)
CHASSIS: C411.2, J401.SH; also elsewhere on the board
ETH_CSn: U401.32 (~SCS); also elsewhere on the board
ETH_INTn: U401.36 (~INT); also elsewhere on the board
ETH_RSTn: U401.37 (~RST); also elsewhere on the board
GND: C401.2, C402.2, C403.2, C404.2, C405.2, C406.2, C407.2, C408.2, C409.2, C410.2, C412.2, C413.2, R401.2, U401.3 (AGND), U401.9 (AGND), U401.14 (AGND), U401.16 (AGND), U401.19 (AGND), U401.29 (GND), U401.48 (AGND); also elsewhere on the board
SPI_MISO: U401.34 (MISO); also elsewhere on the board
SPI_MOSI: U401.35 (MOSI); also elsewhere on the board
SPI_SCK: U401.33 (SCLK); also elsewhere on the board
VCC_3V3: C403.1, C404.1, C405.1, C406.1, C407.1, R410.1, U401.4 (AVDD), U401.8 (AVDD), U401.11 (AVDD), U401.15 (AVDD), U401.17 (AVDD), U401.21 (AVDD), U401.28 (VDD), U401.43 (PMODE2), U401.44 (PMODE1), U401.45 (PMODE0); also elsewhere on the board

Notes on the sheet:
WHY DISCRETE MAGNETICS AND NOT A MAGJACK. Neutrik etherCON (H6) is a rugged SHELL around a plain RJ45 — it contains no magnetics at all. So unlike the usual "HR911105A magjack" design, the transformer has to be a separate part: T401 (PT61017PEL, 10/100 with centre taps). Chain: etherCON J401 -> T40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

Parts:
C201, C203, C204, C206: 100nF; C_0402_1005Metric
C202, C205: 10uF; C_0805_2012Metric
C207: 4.7nF; C_0603_1608Metric
D201: NUP2105L; SOT-23
FB201: 600R@100MHz; L_0603_1608Metric
J201: etherCON NE8FBH CAN A; Neutrik_etherCON_NE8FBH
J202: etherCON NE8FBH CAN B; Neutrik_etherCON_NE8FBH
R201: 0R; R_0402_1005Metric
R202, R203: 62R; R_0603_1608Metric
SW201: TERMINATE 120R; SW_DIP_SPSTx02_Slide_9.78x7.26mm_W7.62mm_P2.54mm
U201: ADM3053BRWZ; SOIC-20W_7.5x12.8mm_P1.27mm

Connections:
/dbCAN — ADM3053 isolated, 2x etherCON/CANH: D201.1 (K), J201.4, J202.4, R202.1, U201.17 (CANH)
/dbCAN — ADM3053 isolated, 2x etherCON/CANL: D201.3 (A), J201.5, J202.5, R203.2, U201.15 (CANL)
/dbCAN — ADM3053 isolated, 2x etherCON/CAN_GND: C204.2, C205.2, C206.2, C207.2, D201.2 (K), J201.SH, J202.SH, R201.2, U201.11 (GND2), U201.13 (GND2), U201.16 (GND2), U201.20 (GND2)
/dbCAN — ADM3053 isolated, 2x etherCON/CAN_RS: R201.1, U201.18 (RS)
/dbCAN — ADM3053 isolated, 2x etherCON/TERM_A: R202.2, SW201.3
/dbCAN — ADM3053 isolated, 2x etherCON/TERM_B: R203.1, SW201.1
/dbCAN — ADM3053 isolated, 2x etherCON/TERM_MID: C207.1, SW201.2, SW201.4
/dbCAN — ADM3053 isolated, 2x etherCON/VISO: C205.1, C206.1, FB201.2, U201.19 (VISOIN)
/dbCAN — ADM3053 isolated, 2x etherCON/VISO_RAW: C204.1, FB201.1, U201.12 (VISOOUT)
CAN_RX: U201.4 (RXD); also elsewhere on the board
CAN_TX: U201.5 (TXD); also elsewhere on the board
GND: C201.2, C202.2, C203.2, U201.1 (GND1), U201.3 (GND1), U201.7 (GND1), U201.9 (GND1), U201.10 (GND1); also elsewhere on the board
VCC_3V3: C203.1, U201.6 (VIO); also elsewhere on the board
VCC_5V: C201.1, C202.1, U201.8 (VCC); also elsewhere on the board

Notes on the sheet:
ISOLATION BARRIER — U201 separates GND (logic) from CAN_GND (bus). No copper on ANY layer may cross under the ADM3053: no pour, no plane, no stitching vias. CAN_GND must stay galvanically separate from GND everywhere.
dbCAN wiring per d&b TI 312: RJ45 pin 4 = CAN_H, pin 5 = CAN_L, SHELL = CAN ground (carried on the cable shield — shielded jacks are mandatory). J201/J202 are wired in PARALLEL so amplifiers daisy-chain, exactly as the R70 does. Pins 1,2,3,6,7,8 are unused by dbCAN and are flagged no-connect. Bus i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
Split termination: 2x62R with C207 to CAN_GND = 120R differential plus a common-mode path. SW201 is 2-pole so BOTH legs break — an SPST would leave an asymmetric 62R+C stub on CANL when open. The R70 uses a plain switched 120R; this is deliberately better for EMC. R201 sets ADM3053 slope control: f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
