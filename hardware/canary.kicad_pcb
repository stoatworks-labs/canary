# Repository stoatworks-labs/canary (continued)

## KiCad design hardware/canary.kicad_pcb (continued)

Board: 4 copper layers, 100.0 x 81.0 mm, 76 parts (0 on the bottom side), 65 nets.

File hardware/fab/generic/dbcanary-bom.csv (part):

Item,Qty,References,Value,Footprint,Description,Manufacturer,MPN,LCSC,Mount,DNP,Notes
1,14,"C105,C108,C201,C203,C204,C206,C302-C304,C404-C407,C409",100nF (BST) / 100nF / 100nF (VBG),C_0402_1005Metric,CAP CER 100nF 16V X7R 0402,Samsung Electro-Mechanics,CL05B104KO5NNNC,C1525,smt,,"DigiKey UK 8,392,367 in stock 2026-07-26"
2,2,"C106,C301",22uF 16V / 22uF,C_0805_2012Metric,CAP CER 22uF 25V X5R 0805,Samsung Electro-Mechanics,CL21A226MAQNNNE,C45783,smt,,"was CL21A226MAQNNNE (Samsung): OBSOLETE, no longer manufactured; even Samsung's own CL21A226MAYNNNE replacement is out of stock. Substitute 55,097 in stock 2026-07-26. Same 0805, 25V X5R. | PCB Train UK alternate: KYOCERA AVX KGM21AR51E226MU"
3,4,"C107,C202,C205,C403",10uF 16V / 10uF,C_0805_2012Metric,CAP CER 10uF 25V X5R 0805,Samsung Electro-Mechanics,CL21A106KAYNNNE,C15850,smt,,"was CL21A106KAYNNNE (Samsung): 0 stock at DigiKey UK, 49-week factory lead time. Substitute 275,536 in stock 2026-07-26. Same 0805 land pattern, same 25V X5R. | PCB Train UK alternate: Taiyo Yuden TMK212BBJ106KGHT"
4,1,C109,1uF,C_0402_1005Metric,CAP CER 1uF 25V X5R 0402,Samsung Electro-Mechanics,CL05A105KA5NQNC,C52923,smt,,"DigiKey UK 1,871,894 in stock 2026-07-26"
5,1,C207,4.7nF,C_0603_1608Metric,CAP CER 4.7nF 50V X7R 0603,FH (Guangdong Fenghua Advanced Tech),0603B472K500NT,C53987,smt,,"was 0603B472K500NT (Fenghua): China-domestic, not stocked in the West. Substitute 3,125,426 in stock 2026-07-26. | PCB Train UK alternate: Samsung Electro-Mechanics CL10B472KB8NNNC"
6,2,"C401,C402",18pF,C_0402_1005Metric,CAP CER 18pF 50V C0G/NP0 0402,FH (Guangdong Fenghua Advanced Tech),0402CG180J500NT,C1549,smt,,"was 0402CG180J500NT (Fenghua): China-domestic. Substitute 542,765 in stock 2026-07-26. C0G confirmed - these are the crystal load caps, so the dielectric matters. | PCB Train UK alternate: Samsung Electro-Mechanics CL05C180JB5NNNC"
7,2,"C408,C410",4.7uF (1V2O) / 4.7uF (TOCAP),C_0603_1608Metric,CAP CER 4.7uF 16V X5R 0603,Samsung Electro-Mechanics,CL10A475KO8NNNC,C19666,smt,,"DigiKey UK 118,638 in stock 2026-07-26"
8,1,C411,1nF 2kV,C_1206_3216Metric,CAP CER 1nF 2kV X7R 1206,FH (Guangdong Fenghua Advanced Tech),1206B102K202NT,C9196,smt,,"was 1206B102K202NT (Fenghua): China-domestic. Substitute confirmed 2000V X7R 1206, 295,090 in stock 2026-07-26. SAFETY-RELEVANT: this is the capacitor bridging the CAN isolation barrier - the 2kV rating is the reason it is a 1206. | PCB Train UK alternate: YAGEO CC1206KKX7RDBB102"
9,1,C412,10nF (TCT),C_0402_1005Metric,CAP CER 10nF 50V X7R 0402,Samsung Electro-Mechanics,CL05B103KB5NNNC,C15195,smt,,"DigiKey UK 6,151,308 in stock 2026-07-26"
10,1,C413,6.8nF (RCT),C_0402_1005Metric,CAP CER 6.8nF 50V X7R 0402,YAGEO,CC0402KRX7R9BB682,C93654,smt,,"DigiKey UK 76,814 in stock 2026-07-26"
11,1,D201,NUP2105L,SOT-23,TVS DIODE 24VWM 44VC SOT-23,TECH PUBLIC,NUP2105LT1G,C2890118,smt,,"MANUFACTURER CORRECTED: the JLCPCB BOM credited this to 'TECH PUBLIC', which is a clone house. onsemi is the originator and DigiKey UK stocks it at GBP 0.33 2026-07-26. Buy the onsemi part - it is an ESD device on an isolated bus."
12,3,"D301,D303,D304",LAN (green) / CAN (green) / ON (green),LED_0603_1608Metric,LED GREEN CLEAR 0603 SMD,Hubei KENTO Elec,KT-0603G,C12624,smt,,"was KT-0603G (Hubei KENTO): China-domestic. Substitute 1,892,900 in stock 2026-07-26. Active low, 1k series resistor - forward voltage is not critical. | PCB Train UK alternate: Lite-On Inc. LTST-C190KGKT"
13,1,D302,ERR (red),LED_0603_1608Metric,LED RED CLEAR 0603 SMD,Hubei KENTO Elec,KT-0603R,C2286,smt,,"was KT-0603R (Hubei KENTO): China-domestic. Substitute 1,033,054 in stock 2026-07-26. Same Lite-On family as the greens, so one series and one datasheet covers all four LEDs. | PCB Train UK alternate: Lite-On Inc. LTST-C190KRKT"
14,1,F101,PTC 1.1A,Fuse_1206_3216Metric,PTC RESETTABLE FUSE 1.1A HOLD 16V 1206,BHFUSE,BSMD1206-110-30V,C21714343,smt,,"was BSMD1206-110-30V (BHFUSE): China-domestic, rated 30V. **THE 30V RATING CANNOT BE MET IN 1206.** A survey of DigiKey UK's 1206 PPTCs at 1.1A hold found 16V to be the highest available (this part, 3,066 in stock); everything else was 6V. 16V is comfortable for the 5V VBUS this board actually runs on - CH224K is configured for a 5V contract - but it does NOT cover the 20V a PD supply could present if that ever changed. DESIGNER TO CONFIRM. The alternative is a larger package in rev B. Verified 2026-07-26. | PCB Train UK alternate: Bourns Inc. MF-NSMF110/16X-2"
15,1,FB201,600R@100MHz,L_0603_1608Metric,FERRITE BEAD 600 OHM @ 100MHz 0603,Murata Electronics,BLM18AG601SN1D,C19330,smt,,"DigiKey UK 2,148,543 in stock 2026-07-26"
16,1,J102,USB-C 16P,USB_C_Receptacle_HRO_TYPE-C-31-M-12,CONN RCPT USB-C 16P SMD,Korean Hroparts Elec,TYPE-C-31-M-12,C165948,smt,,"China-domestic, and the KiCad land pattern (USB_C_Receptacle_HRO_TYPE-C-31-M-12) is drawn for THIS part. Western 16-pin USB-C receptacles exist but pin and shell geometry vary between makers, so a swap cannot be assumed to drop in. FREE ISSUE is the low-risk route: buy from LCSC and send them in. If PCB Train are to source it, they must confirm the mechanical drawing against the footprint first."
17,3,"J201,J202,J401",etherCON NE8FBH CAN A / etherCON NE8FBH CAN B / etherCON NE8FBH LAN,Neutrik_etherCON_NE8FBH,CONN RCPT ETHERCON CAT5 B-SERIES PCB,Neutrik,NE8FBH,,tht,,"MPN ADDED - this line was blank on the JLCPCB BOM because JLC cannot hand-fit it. PCB Train do through-hole assembly, so unlike JLCPCB they CAN fit these. DigiKey UK GBP 6.31 2026-07-26."
18,1,J301,UART/debug 1.27mm,PinHeader_1x06_P1.27mm_Vertical,HEADER 1x6 1.27mm PITCH VERTICAL THROUGH-HOLE - NOT FITTED,DO NOT FIT,DO NOT FIT,,tht,,"DO NOT FIT. A 1x6 1.27mm SINGLE-ROW THROUGH-HOLE header is an awkward part - the 1.27mm parts carried by DigiKey UK are all either dual-row or SMD (M50-3600642, 20021121-00006T4LF, FTSH-106-01-L-DV all checked and all wrong). This is only a UART/debug header and the ESP32-S3's native USB already gives console access, so it is not needed to bring the board up. Leave the holes empty and fit a header by hand if ever wanted."
19,1,L102,2.2uH 2A,L_Bourns-SRN4018,INDUCTOR 2.2uH 2.9A SHIELDED DRUM,BOURNS,SRN4018-2R2M,C913207,smt,,"DigiKey UK 86,769 in stock 2026-07-26"
20,1,R103,31.6k 1%,R_0402_1005Metric,RES 31.6k 1% 0402,UNI-ROYAL(Uniroyal Elec),0402WGF3162TCE,C11463,smt,,"was UNI-ROYAL (China-domestic, not stocked in the West). DigiKey UK 1,526,832 in stock 2026-07-26. | PCB Train UK alternate: YAGEO RC0402FR-0731K6L"
21,3,"R104,R107,R301",10k 1% / 10k,R_0402_1005Metric,RES 10k 1% 0402,UNI-ROYAL(Uniroyal Elec),0402WGF1002TCE,C25744,smt,,"was UNI-ROYAL (China-domestic). NOTE the -13 series code, not -07: RC0402FR-0710KL is the same value but had only 762 in stock, whereas -13 had 79,602 2026-07-26. Electrically identical. | PCB Train UK alternate: YAGEO RC0402FR-1310KL"
22,5,"R106,R302-R305",1k,R_0402_1005Metric,RES 1k 1% 0402,UNI-ROYAL(Uniroyal Elec),0402WGF1001TCE,C11702,smt,,"was UNI-ROYAL (China-domestic, not stocked in the West). DigiKey UK 11,751,037 in stock 2026-07-26. | PCB Train UK alternate: YAGEO RC0402FR-071KL"
23,2,"R201,R412",0R / 0R (XO series),R_0402_1005Metric,RES 0 ohm jumper 0402,UNI-ROYAL(Uniroyal Elec),0402WGF0000TCE,C17168,smt,,"was UNI-ROYAL (China-domestic). DigiKey UK 10,726,477 in stock 2026-07-26. J-series because a jumper has no meaningful tolerance. | PCB Train UK alternate: YAGEO RC0402JR-070RL"
24,2,"R202,R203",62R,R_0603_1608Metric,RES 62R 1% 0603,UNI-ROYAL(Uniroyal Elec),0603WAF620JT5E,C23222,smt,,"was UNI-ROYAL (China-domestic, not stocked in the West). DigiKey UK 51,612 in stock 2026-07-26. | PCB Train UK alternate: YAGEO RC0603FR-0762RL"
25,1,R401,12.4k 1%,R_0402_1005Metric,RES 12.4k 1% 0402,UNI-ROYAL(Uniroyal Elec),0402WGF1242TCE,C11692,smt,,"was UNI-ROYAL (China-domestic, not stocked in the West). DigiKey UK 582,138 in stock 2026-07-26. | PCB Train UK alternate: YAGEO RC0402FR-0712K4L"
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
## Code that names these connections

File hardware/scripts/probe_points.py (part):

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          "3.3 - 5.1 V",
          "0 V = R106 open or U104 shorted; the exact value depends on CH224K Iq, which we have not measured",
          "PWR", "predicted", (1, -1)),
    Probe("P6", "U104.10", "PD_PG", "CH224K power-good to GPIO18", "DMM-V",
          "logic level, stable; note which level a good board shows",
          "the polarity is unverified - record it on board #1 and make that the limit",
          "PWR", "predicted", (1, 1)),
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          "3.23 - 3.43 V",
          "the header is the fallback console when USB will not enumerate",
          "MCU", "derived", (1, -1)),
    Probe("M3", "J301.3", "UART0_TXD", "debug header pin 3, board -> host", "SCOPE",
          "idle high 3.3 V, 115200 baud bursts at reset",
          "silent at reset = the S3 is not running its ROM bootloader",
          "MCU", "derived", (1, 1)),
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          "3.23 - 3.43 V, and D304 lit",
          "rail present but D304 dark = LED fitted backwards or R305 open",
          "MCU", "derived", (-1, 1)),
    Probe("M6", "R302.1", "LED_LAN", "D301 drive from GPIO15", "DMM-V",
          "ACTIVE HIGH: ~3.3 V when lit, ~0 V when dark",
          "see the polarity note in BENCH-BRINGUP.md - the schematic is active high",
          "MCU", "derived", (-1, -1)),
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          "0x04 in the 4th byte of that transaction",
          "0x00 or 0xFF = W5500 not answering: supply, crystal or reset",
          "ETH", "spec", (2.6, -1.0)),
    Probe("E10", "U401.37", "ETH_RSTn", "W5500 reset, from GPIO9", "DMM-V",
          "3.23 - 3.43 V once firmware has run",
          "low = held in reset, and every SPI read returns 0x00",
          "ETH", "derived", (-1, -1)),
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          "under 0.3 V to CAN_GND - R201 is 0R, so high-speed mode",
          "volts here = R201 missing, and the transceiver drops to standby",
          "CAN", "spec", (1, -1)),
    Probe("K5", "J201.4", "CANH", "bus high, at CAN jack A (pin 4)", "DMM-V",
          "idle 2.3 - 2.7 V to CAN_GND; K5-K6 reads 118-130 ohm with SW201 IN, "
          "over 10 kohm with it OUT",
          "0 V or 5 V = the transceiver is stuck dominant, which jams the whole bus",
          "CAN", "spec", (-1, -1)),
    Probe("K6", "J201.5", "CANL", "bus low, at CAN jack A (pin 5)", "DMM-V",
          "idle 2.3 - 2.7 V to CAN_GND, within 100 mV of K5",
          "the K5-K6 resistance also tells a CAN jack from the LAN jack when the "
          "silkscreen is unreadable: only J201/J202 show 124 ohm",
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